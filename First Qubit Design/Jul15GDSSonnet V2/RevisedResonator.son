RevisedResonator.son:
```
FTYP SONPROJ 15 ! Sonnet Project File
VER 16.52
HEADER
LIC calt2.2.43068 b6ae2bd1257f DESKTOP-SL82IK9 Michael
DAT 07/15/2016 19:11:39
BUILT_BY_CREATED xgeom 16.52 04/11/2016 14:48:12
BUILT_BY_SAVED xgeom 16.52
MDATE 07/15/2016 19:11:39
HDATE 07/15/2016 19:11:27
END HEADER
DIM
FREQ GHZ
IND NH
LNG UM
ANG DEG
CON /OH
CAP PF
RES OH
END DIM
FREQ
ABS 6.0 8.0 
END FREQ
CONTROL
ABS
OPTIONS  -d 
SPEED 0
CACHE_ABS 1
TARG_ABS 300
Q_ACC Y
DET_ABS_RES Y
END CONTROL
GEO
TMET "Lossless" 0 SUP 0 0 0 0
BMET "Lossless" 0 SUP 0 0 0 0
MET "Unknown_metal" 1 NOR INF 0 0 
BOX 1 752 2238 752 2238 20 0
      1000 1 1 0 0 0 0 "Unnamed"
      500 11.9 1 5e-006 0 0 0 "Silicon (intrinsic)"
LORGN 0 2238 U 
POR1 STD
POLY 1107 1
1
1 50 0 0 0 0 222 
POR1 STD
POLY 1114 1
3
2 50 0 0 0 752 222 
NUM 21
0 5 -1 N 1089 1 1 100 100 0 0 0 Y
305 1869
281 1869
281 2238
305 2238
305 1869
END
0 107 -1 N 1095 1 1 100 100 0 0 0 Y
251 1839
335 1839
335 2005
337 2005
337 1837
249 1837
249 2005
205 2005
205 1793
282 1793
282 1790.84
282 1786.75
282 1782.67
282 1778.59
282 1774.51
282 1770.43
282 1766.35
282 1762.26
282 1758.18
282 1754.1
282 1750.02
282 1745.94
282 1741.86
282 1737.78
282 1733.69
282 1729.61
282 1725.53
282 1721.45
282 1717.37
282 1713.28
282 1709.2
282 1705.12
282 1701.04
282 1696.96
282 1692.88
282 1688.79
282 1684.71
282 1680.63
282 1676.55
282 1672.47
282 1668.39
282 1664.31
282 1660.22
282 1656.14
282 1652.06
282 1647.98
282 1643.9
282 1639.82
282 1635.73
282 1631.65
282 1627.57
282 1623.49
282 1619.41
282 1615.33
282 1611.24
282 1607.16
282 1603.08
282 1599
282 1594.92
282 1590.84
282 1586.75
282 1582.67
282 1578.59
282 1574.51
282 1570.43
282 1566.35
282 1562.26
282 1558.18
282 1554.1
282 1550.02
282 1545.94
282 1541.86
282 1537.78
282 1533.69
282 1529.61
282 1525.53
282 1521.45
282 1517.37
282 1513.28
282 1509.2
282 1505.12
282 1501.04
282 1496.96
282 1492.88
282 1488.79
282 1484.71
282 1480.63
282 1476.55
282 1472.47
282 1468.39
282 1464.3
282 1460.22
282 1456.14
282 1452.06
282 1447.98
282 1443.9
282 1439.82
282 1435.73
282 1431.65
282 1427.57
282 1423.49
282 1419.41
282 1419
0 1419
0 2238
251 2238
251 1839
END
0 199 -1 N 1096 1 1 100 100 0 0 0 Y
375 1799
298 1799
298 1794.92
298 1790.84
298 1786.75
298 1782.67
298 1778.59
298 1774.51
298 1770.43
298 1766.35
298 1762.26
298 1758.18
298 1754.1
298 1750.02
298 1745.94
298 1741.86
298 1737.78
298 1733.69
298 1729.61
298 1725.53
298 1721.45
298 1717.37
298 1713.28
298 1709.2
298 1705.12
298 1701.04
298 1696.96
298 1692.88
298 1688.8
298 1684.71
298 1680.63
298 1676.55
298 1672.47
298 1668.39
298 1664.31
298 1660.22
298 1656.14
298 1652.06
298 1647.98
298 1643.9
298 1639.82
298 1635.73
298 1631.65
298 1627.57
298 1623.49
298 1619.41
298 1615.33
298 1611.24
298 1607.16
298 1603.08
298 1599
298 1594.92
298 1590.84
298 1586.75
298 1582.67
298 1578.59
298 1574.51
298 1570.43
298 1566.35
298 1562.26
298 1558.18
298 1554.1
298 1550.02
298 1545.94
298 1541.86
298 1537.78
298 1533.69
298 1529.61
298 1525.53
298 1521.45
298 1517.37
298 1513.28
298 1509.2
298 1505.12
298 1501.04
298 1496.96
298 1492.88
298 1488.8
298 1484.71
298 1480.63
298 1476.55
298 1472.47
298 1468.39
298 1464.31
298 1460.22
298 1456.14
298 1452.06
298 1447.98
298 1443.9
298 1439.82
298 1435.73
298 1431.65
298 1427.57
298 1423.49
298 1419.41
298 1419
288 1419
288 1419.41
288 1423.49
288 1427.57
288 1431.65
288 1435.73
288 1439.82
288 1443.9
288 1447.98
288 1452.06
288 1456.14
288 1460.22
288 1464.31
288 1468.39
288 1472.47
288 1476.55
288 1480.63
288 1484.71
288 1488.79
288 1492.88
288 1496.96
288 1501.04
288 1505.12
288 1509.2
288 1513.28
288 1517.37
288 1521.45
288 1525.53
288 1529.61
288 1533.69
288 1537.78
288 1541.86
288 1545.94
288 1550.02
288 1554.1
288 1558.18
288 1562.26
288 1566.35
288 1570.43
288 1574.51
288 1578.59
288 1582.67
288 1586.75
288 1590.84
288 1594.92
288 1599
288 1603.08
288 1607.16
288 1611.24
288 1615.33
288 1619.41
288 1623.49
288 1627.57
288 1631.65
288 1635.73
288 1639.82
288 1643.9
288 1647.98
288 1652.06
288 1656.14
288 1660.22
288 1664.31
288 1668.39
288 1672.47
288 1676.55
288 1680.63
288 1684.71
288 1688.79
288 1692.88
288 1696.96
288 1701.04
288 1705.12
288 1709.2
288 1713.29
288 1717.37
288 1721.45
288 1725.53
288 1729.61
288 1733.69
288 1737.78
288 1741.86
288 1745.94
288 1750.02
288 1754.1
288 1758.18
288 1762.26
288 1766.35
288 1770.43
288 1774.51
288 1778.59
288 1782.67
288 1786.75
288 1790.84
288 1794.92
288 1799
211 1799
211 1999
243 1999
243 1831
343 1831
343 1999
375 1999
375 1799
END
0 101 -1 N 1097 1 1 100 100 0 0 0 Y
752 1419
304 1419
304 1419.41
304 1423.49
304 1427.57
304 1431.65
304 1435.73
304 1439.82
304 1443.9
304 1447.98
304 1452.06
304 1456.14
304 1460.22
304 1464.31
304 1468.39
304 1472.47
304 1476.55
304 1480.63
304 1484.71
304 1488.8
304 1492.88
304 1496.96
304 1501.04
304 1505.12
304 1509.2
304 1513.29
304 1517.37
304 1521.45
304 1525.53
304 1529.61
304 1533.69
304 1537.77
304 1541.86
304 1545.94
304 1550.02
304 1554.1
304 1558.18
304 1562.26
304 1566.35
304 1570.43
304 1574.51
304 1578.59
304 1582.67
304 1586.75
304 1590.84
304 1594.92
304 1599
304 1603.08
304 1607.16
304 1611.24
304 1615.33
304 1619.41
304 1623.49
304 1627.57
304 1631.65
304 1635.73
304 1639.82
304 1643.9
304 1647.98
304 1652.06
304 1656.14
304 1660.22
304 1664.31
304 1668.39
304 1672.47
304 1676.55
304 1680.63
304 1684.71
304 1688.8
304 1692.88
304 1696.96
304 1701.04
304 1705.12
304 1709.2
304 1713.29
304 1717.37
304 1721.45
304 1725.53
304 1729.61
304 1733.69
304 1737.78
304 1741.86
304 1745.94
304 1750.02
304 1754.1
304 1758.18
304 1762.26
304 1766.35
304 1770.43
304 1774.51
304 1778.59
304 1782.67
304 1786.75
304 1790.84
304 1793
381 1793
381 2005
335 2005
335 2238
752 2238
752 1419
END
0 1401 -1 V 1101 1 1 100 100 0 0 0 Y
298 1415.33
298 1411.24
298 1407.16
298 1403.08
298 1399
297.99 1398.12
297.97 1397.24
297.94 1396.35
297.89 1395.48
297.82 1394.6
297.75 1393.72
297.65 1392.84
297.55 1391.97
297.43 1391.09
297.3 1390.22
297.15 1389.35
296.99 1388.49
296.81 1387.62
296.62 1386.76
296.42 1385.9
296.2 1385.05
295.97 1384.2
295.73 1383.35
295.47 1382.51
295.2 1381.67
294.91 1380.83
294.62 1380
294.3 1379.18
293.98 1378.36
293.64 1377.55
293.29 1376.74
292.93 1375.93
292.55 1375.14
292.17 1374.34
291.76 1373.56
291.35 1372.78
290.92 1372.01
290.48 1371.25
290.03 1370.49
289.57 1369.74
289.1 1368.99
288.61 1368.26
288.11 1367.53
287.6 1366.81
287.08 1366.1
286.55 1365.4
286 1364.71
285.45 1364.02
284.88 1363.35
284.3 1362.68
283.72 1362.02
283.12 1361.37
282.51 1360.74
281.89 1360.11
281.26 1359.49
280.63 1358.88
279.98 1358.28
279.32 1357.7
278.65 1357.12
277.98 1356.55
277.29 1356
276.6 1355.45
275.9 1354.92
275.19 1354.4
274.47 1353.89
273.74 1353.39
273.01 1352.9
272.26 1352.43
271.51 1351.97
270.76 1351.52
269.99 1351.08
269.22 1350.65
268.44 1350.24
267.66 1349.83
266.86 1349.45
266.07 1349.07
265.26 1348.71
264.45 1348.36
263.64 1348.02
262.82 1347.69
262 1347.38
261.17 1347.08
260.33 1346.8
259.49 1346.53
258.65 1346.27
257.8 1346.03
256.95 1345.8
256.1 1345.58
255.24 1345.38
254.38 1345.19
253.52 1345.01
252.65 1344.85
251.78 1344.7
250.91 1344.57
250.03 1344.45
249.16 1344.35
248.28 1344.25
247.4 1344.18
246.52 1344.11
245.65 1344.06
244.76 1344.03
243.88 1344.01
243 1344
241.56 1343.98
240.12 1343.91
238.68 1343.79
237.25 1343.63
235.82 1343.42
234.4 1343.17
232.99 1342.87
231.59 1342.53
230.2 1342.14
228.82 1341.71
227.46 1341.23
226.11 1340.71
224.79 1340.15
223.48 1339.54
222.19 1338.9
220.92 1338.21
219.67 1337.48
218.45 1336.71
217.26 1335.91
216.09 1335.06
214.94 1334.18
213.83 1333.26
212.75 1332.31
211.69 1331.32
210.68 1330.31
209.69 1329.25
208.74 1328.17
207.82 1327.06
206.94 1325.91
206.09 1324.74
205.29 1323.55
204.52 1322.33
203.79 1321.08
203.1 1319.81
202.46 1318.52
201.85 1317.21
201.29 1315.89
200.77 1314.54
200.29 1313.18
199.86 1311.8
199.47 1310.41
199.13 1309.01
198.83 1307.6
198.58 1306.18
198.37 1304.75
198.21 1303.32
198.09 1301.88
198.02 1300.44
198 1299
198.02 1297.56
198.09 1296.12
198.21 1294.68
198.37 1293.24
198.58 1291.82
198.83 1290.4
199.13 1288.99
199.47 1287.58
199.86 1286.19
200.29 1284.82
200.77 1283.46
201.29 1282.11
201.85 1280.78
202.46 1279.47
203.1 1278.18
203.79 1276.92
204.52 1275.67
205.29 1274.45
206.09 1273.25
206.94 1272.08
207.82 1270.94
208.74 1269.83
209.69 1268.75
210.68 1267.69
211.69 1266.67
212.75 1265.69
213.83 1264.73
214.94 1263.82
216.09 1262.93
217.26 1262.09
218.45 1261.28
219.67 1260.52
220.92 1259.79
222.19 1259.1
223.48 1258.46
224.79 1257.85
226.11 1257.29
227.46 1256.77
228.82 1256.29
230.2 1255.86
231.59 1255.47
232.99 1255.13
234.4 1254.83
235.82 1254.58
237.25 1254.37
238.68 1254.21
240.12 1254.09
241.56 1254.02
243 1254
543 1254
544.76 1253.97
546.52 1253.89
548.28 1253.74
550.03 1253.55
551.78 1253.29
553.51 1252.98
555.24 1252.62
556.95 1252.2
558.65 1251.73
560.33 1251.2
561.99 1250.61
563.64 1249.98
565.26 1249.29
566.86 1248.55
568.44 1247.76
569.99 1246.92
571.51 1246.03
573 1245.09
574.47 1244.11
575.9 1243.08
577.29 1242
578.65 1240.88
579.98 1239.71
581.26 1238.51
582.51 1237.26
583.72 1235.98
584.88 1234.65
586 1233.29
587.08 1231.89
588.11 1230.46
589.1 1229
590.03 1227.51
590.92 1225.99
591.76 1224.44
592.55 1222.86
593.29 1221.26
593.98 1219.64
594.62 1217.99
595.2 1216.33
595.73 1214.65
596.2 1212.95
596.62 1211.24
596.99 1209.51
597.3 1207.78
597.55 1206.03
597.75 1204.28
597.89 1202.52
597.97 1200.76
598 1199
597.97 1197.24
597.89 1195.47
597.75 1193.72
597.55 1191.97
597.3 1190.22
596.99 1188.49
596.62 1186.76
596.2 1185.05
595.73 1183.35
595.2 1181.67
594.62 1180
593.98 1178.36
593.29 1176.74
592.55 1175.14
591.76 1173.56
590.92 1172.01
590.03 1170.49
589.1 1168.99
588.11 1167.53
587.08 1166.1
586 1164.71
584.88 1163.35
583.72 1162.02
582.51 1160.74
581.26 1159.49
579.98 1158.28
578.65 1157.12
577.29 1156
575.9 1154.92
574.47 1153.89
573 1152.9
571.51 1151.97
569.99 1151.08
568.44 1150.24
566.86 1149.45
565.26 1148.71
563.64 1148.02
561.99 1147.38
560.33 1146.8
558.65 1146.27
556.95 1145.8
555.24 1145.38
553.51 1145.01
551.78 1144.7
550.03 1144.45
548.28 1144.25
546.52 1144.11
544.76 1144.03
543 1144
243 1144
241.56 1143.98
240.12 1143.91
238.68 1143.79
237.25 1143.63
235.82 1143.42
234.4 1143.17
232.99 1142.87
231.59 1142.53
230.2 1142.14
228.82 1141.71
227.46 1141.23
226.11 1140.71
224.79 1140.15
223.48 1139.54
222.19 1138.9
220.92 1138.21
219.67 1137.48
218.45 1136.71
217.26 1135.91
216.09 1135.06
214.94 1134.18
213.83 1133.26
212.75 1132.31
211.69 1131.33
210.67 1130.3
209.69 1129.25
208.74 1128.17
207.82 1127.06
206.94 1125.91
206.09 1124.74
205.29 1123.55
204.52 1122.33
203.79 1121.08
203.1 1119.81
202.46 1118.52
201.85 1117.21
201.29 1115.89
200.77 1114.54
200.29 1113.18
199.86 1111.8
199.47 1110.41
199.13 1109.01
198.83 1107.6
198.58 1106.18
198.37 1104.75
198.21 1103.32
198.09 1101.88
198.02 1100.44
198 1099
198.02 1097.56
198.09 1096.12
198.21 1094.68
198.37 1093.24
198.58 1091.82
198.83 1090.4
199.13 1088.99
199.47 1087.58
199.86 1086.19
200.29 1084.82
200.77 1083.46
201.29 1082.11
201.85 1080.78
202.46 1079.47
203.1 1078.18
203.79 1076.92
204.52 1075.67
205.29 1074.45
206.09 1073.25
206.94 1072.08
207.82 1070.94
208.74 1069.83
209.69 1068.74
210.68 1067.69
211.69 1066.67
212.75 1065.69
213.83 1064.73
214.94 1063.82
216.09 1062.94
217.26 1062.09
218.45 1061.28
219.67 1060.52
220.92 1059.79
222.19 1059.1
223.48 1058.45
224.79 1057.85
226.11 1057.29
227.46 1056.77
228.82 1056.29
230.2 1055.86
231.59 1055.47
232.99 1055.13
234.4 1054.83
235.82 1054.58
237.25 1054.37
238.68 1054.21
240.12 1054.09
241.56 1054.02
243 1054
543 1054
544.76 1053.97
546.52 1053.89
548.28 1053.74
550.03 1053.55
551.78 1053.29
553.51 1052.98
555.24 1052.62
556.95 1052.2
558.65 1051.73
560.33 1051.2
561.99 1050.62
563.64 1049.98
565.26 1049.29
566.86 1048.55
568.44 1047.76
569.99 1046.92
571.51 1046.03
573 1045.09
574.47 1044.11
575.9 1043.08
577.29 1042
578.65 1040.88
579.98 1039.71
581.26 1038.51
582.51 1037.26
583.72 1035.98
584.88 1034.65
586 1033.29
587.08 1031.89
588.11 1030.47
589.1 1029
590.03 1027.51
590.92 1025.99
591.76 1024.44
592.55 1022.86
593.29 1021.26
593.98 1019.64
594.62 1017.99
595.2 1016.33
595.73 1014.65
596.2 1012.95
596.62 1011.24
596.99 1009.51
597.3 1007.78
597.55 1006.03
597.75 1004.28
597.89 1002.52
597.97 1000.76
598 999
597.97 997.24
597.89 995.47
597.75 993.72
597.55 991.97
597.3 990.22
596.99 988.49
596.62 986.76
596.2 985.05
595.73 983.35
595.2 981.67
594.62 980
593.98 978.36
593.29 976.74
592.55 975.14
591.76 973.56
590.92 972.01
590.03 970.49
589.1 968.99
588.11 967.53
587.08 966.1
586 964.71
584.88 963.35
583.72 962.02
582.51 960.74
581.26 959.49
579.98 958.28
578.65 957.12
577.29 956
575.9 954.92
574.47 953.89
573 952.9
571.51 951.97
569.99 951.08
568.44 950.24
566.86 949.45
565.26 948.71
563.64 948.02
561.99 947.38
560.33 946.8
558.65 946.27
556.95 945.8
555.24 945.38
553.51 945.01
551.78 944.7
550.03 944.45
548.28 944.25
546.52 944.11
544.76 944.03
543 944
243 944
241.56 943.98
240.12 943.91
238.68 943.79
237.25 943.63
235.82 943.42
234.4 943.17
232.99 942.87
231.59 942.53
230.2 942.14
228.82 941.71
227.46 941.23
226.11 940.71
224.79 940.15
223.48 939.54
222.19 938.9
220.92 938.21
219.67 937.48
218.45 936.71
217.26 935.91
216.09 935.06
214.94 934.18
213.83 933.26
212.75 932.31
211.69 931.32
210.68 930.31
209.69 929.25
208.74 928.17
207.82 927.06
206.94 925.91
206.09 924.74
205.29 923.55
204.52 922.33
203.79 921.08
203.1 919.81
202.46 918.52
201.85 917.21
201.29 915.89
200.77 914.54
200.29 913.18
199.86 911.8
199.47 910.41
199.13 909.01
198.83 907.6
198.58 906.18
198.37 904.75
198.21 903.32
198.09 901.88
198.02 900.44
198 899
198.02 897.56
198.09 896.12
198.21 894.68
198.37 893.25
198.58 891.82
198.83 890.4
199.13 888.99
199.47 887.58
199.86 886.2
200.29 884.82
200.77 883.46
201.29 882.11
201.85 880.78
202.46 879.47
203.1 878.18
203.79 876.92
204.52 875.67
205.29 874.45
206.09 873.25
206.94 872.08
207.82 870.94
208.74 869.83
209.69 868.74
210.67 867.69
211.7 866.67
212.75 865.69
213.83 864.73
214.94 863.82
216.09 862.94
217.26 862.09
218.45 861.28
219.67 860.52
220.92 859.79
222.19 859.1
223.48 858.45
224.79 857.85
226.11 857.29
227.46 856.77
228.82 856.29
230.2 855.86
231.59 855.47
232.99 855.13
234.4 854.83
235.82 854.58
237.25 854.37
238.68 854.21
240.12 854.09
241.56 854.02
243 854
543 854
543.88 853.99
544.76 853.97
545.64 853.94
546.52 853.89
547.4 853.82
548.28 853.74
549.16 853.65
550.03 853.55
550.91 853.43
551.78 853.29
552.65 853.15
553.51 852.98
554.38 852.81
555.24 852.62
556.1 852.42
556.95 852.2
557.8 851.97
558.65 851.73
559.49 851.47
560.33 851.2
561.17 850.91
561.99 850.62
562.82 850.3
563.64 849.98
564.45 849.64
565.26 849.29
566.07 848.93
566.86 848.55
567.65 848.16
568.44 847.76
569.22 847.35
569.99 846.92
570.75 846.48
571.51 846.03
572.26 845.57
573 845.09
573.74 844.61
574.47 844.11
575.18 843.6
575.9 843.08
576.6 842.54
577.29 842
577.98 841.44
578.65 840.88
579.32 840.3
579.98 839.71
580.62 839.12
581.26 838.51
581.89 837.89
582.51 837.26
583.12 836.62
583.72 835.98
584.3 835.32
584.88 834.65
585.45 833.98
586 833.29
586.55 832.6
587.08 831.89
587.6 831.18
588.11 830.47
588.61 829.74
589.1 829
589.57 828.26
590.03 827.51
590.48 826.75
590.92 825.99
591.35 825.22
591.76 824.44
592.16 823.65
592.55 822.86
592.93 822.07
593.29 821.26
593.64 820.45
593.98 819.64
594.31 818.82
594.62 817.99
594.91 817.16
595.2 816.33
595.47 815.49
595.73 814.65
595.97 813.8
596.2 812.95
596.42 812.1
596.62 811.24
596.81 810.38
596.99 809.51
597.15 808.65
597.3 807.78
597.43 806.91
597.55 806.03
597.65 805.16
597.75 804.28
597.82 803.4
597.89 802.52
597.94 801.64
597.97 800.76
597.99 799.88
598 799
598 793.9
598 788.8
598 785
588 785
588 788.8
588 793.9
588 799
587.99 799.72
587.98 800.44
587.95 801.16
587.91 801.88
587.86 802.6
587.79 803.32
587.72 804.04
587.63 804.75
587.53 805.47
587.42 806.18
587.3 806.89
587.17 807.6
587.03 808.31
586.87 809.01
586.71 809.71
586.53 810.41
586.34 811.11
586.14 811.8
585.93 812.49
585.71 813.18
585.48 813.86
585.23 814.54
584.98 815.22
584.71 815.89
584.43 816.55
584.15 817.21
583.85 817.87
583.54 818.52
583.23 819.17
582.9 819.81
582.56 820.45
582.21 821.08
581.85 821.71
581.48 822.33
581.1 822.94
580.71 823.55
580.32 824.15
579.91 824.74
579.49 825.33
579.06 825.91
578.63 826.49
578.18 827.06
577.73 827.62
577.27 828.17
576.79 828.72
576.31 829.25
575.82 829.78
575.33 830.31
574.82 830.82
574.31 831.32
573.78 831.82
573.25 832.31
572.72 832.79
572.17 833.26
571.62 833.73
571.06 834.18
570.49 834.63
569.92 835.06
569.33 835.49
568.74 835.91
568.15 836.32
567.55 836.71
566.94 837.1
566.33 837.48
565.71 837.85
565.08 838.21
564.45 838.56
563.81 838.9
563.17 839.22
562.52 839.54
561.87 839.85
561.22 840.15
560.55 840.43
559.89 840.71
559.22 840.98
558.54 841.23
557.86 841.47
557.18 841.71
556.49 841.93
555.8 842.14
555.11 842.34
554.41 842.53
553.72 842.71
553.01 842.87
552.31 843.03
551.6 843.17
550.89 843.3
550.18 843.42
549.47 843.53
548.75 843.63
548.04 843.72
547.32 843.79
546.6 843.85
545.88 843.91
545.16 843.95
544.44 843.98
543.72 843.99
543 844
243 844
241.24 844.03
239.48 844.11
237.72 844.25
235.97 844.45
234.22 844.7
232.49 845.01
230.76 845.38
229.05 845.8
227.35 846.27
225.67 846.8
224.01 847.38
222.36 848.02
220.74 848.71
219.14 849.45
217.56 850.24
216.01 851.08
214.49 851.97
213 852.9
211.53 853.89
210.1 854.92
208.71 856
207.35 857.12
206.02 858.28
204.74 859.49
203.49 860.74
202.29 862.02
201.12 863.35
200 864.71
198.92 866.1
197.89 867.53
196.91 868.99
195.97 870.49
195.08 872.01
194.24 873.56
193.45 875.14
192.71 876.74
192.02 878.36
191.39 880
190.8 881.67
190.27 883.35
189.8 885.05
189.38 886.76
189.01 888.48
188.71 890.22
188.45 891.97
188.26 893.72
188.11 895.48
188.03 897.24
188 899
188.03 900.76
188.11 902.52
188.26 904.28
188.45 906.03
188.71 907.78
189.01 909.51
189.38 911.24
189.8 912.95
190.27 914.65
190.8 916.33
191.39 917.99
192.02 919.64
192.71 921.26
193.45 922.86
194.24 924.44
195.08 925.99
195.97 927.51
196.91 929
197.89 930.47
198.92 931.89
200 933.29
201.12 934.65
202.29 935.98
203.49 937.26
204.74 938.51
206.02 939.71
207.35 940.88
208.71 942
210.1 943.08
211.53 944.11
213 945.09
214.49 946.03
216.01 946.92
217.56 947.76
219.14 948.55
220.74 949.29
222.36 949.98
224.01 950.61
225.67 951.2
227.35 951.73
229.05 952.2
230.76 952.62
232.49 952.99
234.22 953.29
235.97 953.55
237.72 953.74
239.48 953.89
241.24 953.97
243 954
543 954
544.44 954.02
545.88 954.09
547.32 954.21
548.75 954.37
550.18 954.58
551.6 954.83
553.01 955.13
554.41 955.47
555.8 955.86
557.18 956.29
558.54 956.77
559.89 957.29
561.22 957.85
562.52 958.45
563.81 959.1
565.08 959.79
566.33 960.52
567.55 961.28
568.74 962.09
569.92 962.94
571.06 963.82
572.17 964.73
573.25 965.69
574.31 966.67
575.33 967.69
576.31 968.74
577.27 969.83
578.18 970.94
579.06 972.08
579.91 973.25
580.71 974.45
581.48 975.67
582.21 976.92
582.9 978.18
583.54 979.47
584.15 980.78
584.71 982.11
585.23 983.46
585.71 984.82
586.14 986.2
586.53 987.59
586.87 988.99
587.17 990.4
587.42 991.82
587.63 993.25
587.79 994.68
587.91 996.12
587.98 997.56
588 999
587.98 1000.44
587.91 1001.88
587.79 1003.32
587.63 1004.75
587.42 1006.18
587.17 1007.6
586.87 1009.01
586.53 1010.41
586.14 1011.8
585.71 1013.18
585.23 1014.54
584.71 1015.89
584.15 1017.21
583.54 1018.52
582.9 1019.81
582.21 1021.08
581.48 1022.33
580.71 1023.55
579.91 1024.74
579.06 1025.91
578.18 1027.06
577.27 1028.17
576.31 1029.25
575.33 1030.31
574.31 1031.32
573.25 1032.31
572.17 1033.26
571.06 1034.18
569.92 1035.06
568.74 1035.91
567.55 1036.71
566.33 1037.48
565.08 1038.21
563.81 1038.9
562.52 1039.54
561.22 1040.15
559.89 1040.71
558.54 1041.23
557.18 1041.71
555.8 1042.14
554.41 1042.53
553.01 1042.87
551.6 1043.17
550.18 1043.42
548.75 1043.63
547.32 1043.79
545.88 1043.91
544.44 1043.98
543 1044
243 1044
241.24 1044.03
239.48 1044.11
237.72 1044.25
235.97 1044.45
234.22 1044.7
232.49 1045.01
230.76 1045.38
229.05 1045.8
227.35 1046.27
225.67 1046.8
224.01 1047.38
222.36 1048.02
220.74 1048.71
219.14 1049.45
217.56 1050.24
216.01 1051.08
214.49 1051.97
213 1052.9
211.53 1053.89
210.1 1054.92
208.71 1056
207.35 1057.12
206.02 1058.28
204.74 1059.49
203.49 1060.74
202.29 1062.02
201.12 1063.35
200 1064.71
198.92 1066.1
197.89 1067.53
196.91 1068.99
195.97 1070.49
195.08 1072.01
194.24 1073.56
193.45 1075.13
192.71 1076.74
192.02 1078.36
191.39 1080
190.8 1081.67
190.27 1083.35
189.8 1085.05
189.38 1086.76
189.02 1088.49
188.71 1090.22
188.45 1091.97
188.26 1093.72
188.11 1095.47
188.03 1097.24
188 1099
188.03 1100.76
188.11 1102.52
188.26 1104.28
188.45 1106.03
188.71 1107.78
189.01 1109.51
189.38 1111.24
189.8 1112.95
190.27 1114.65
190.8 1116.33
191.39 1117.99
192.02 1119.64
192.71 1121.26
193.45 1122.86
194.24 1124.44
195.08 1125.99
195.97 1127.51
196.91 1129
197.89 1130.47
198.92 1131.89
200 1133.29
201.12 1134.65
202.29 1135.98
203.49 1137.26
204.74 1138.51
206.02 1139.71
207.35 1140.88
208.71 1142
210.1 1143.08
211.53 1144.11
213 1145.09
214.49 1146.03
216.01 1146.92
217.56 1147.76
219.14 1148.55
220.74 1149.29
222.36 1149.98
224.01 1150.61
225.67 1151.2
227.35 1151.73
229.05 1152.2
230.76 1152.62
232.49 1152.99
234.22 1153.29
235.97 1153.55
237.72 1153.75
239.48 1153.89
241.24 1153.97
243 1154
543 1154
544.44 1154.02
545.88 1154.09
547.32 1154.21
548.75 1154.37
550.18 1154.58
551.6 1154.83
553.01 1155.13
554.41 1155.47
555.8 1155.86
557.18 1156.29
558.54 1156.77
559.89 1157.29
561.22 1157.85
562.52 1158.45
563.81 1159.1
565.08 1159.79
566.33 1160.52
567.55 1161.28
568.74 1162.09
569.91 1162.93
571.06 1163.82
572.17 1164.73
573.25 1165.69
574.31 1166.67
575.33 1167.69
576.31 1168.74
577.27 1169.83
578.18 1170.94
579.06 1172.08
579.91 1173.25
580.71 1174.45
581.48 1175.67
582.21 1176.92
582.9 1178.19
583.54 1179.47
584.15 1180.78
584.71 1182.11
585.23 1183.46
585.71 1184.82
586.14 1186.2
586.53 1187.58
586.87 1188.99
587.17 1190.4
587.42 1191.82
587.63 1193.24
587.79 1194.68
587.91 1196.12
587.98 1197.56
588 1199
587.98 1200.44
587.91 1201.88
587.79 1203.32
587.63 1204.75
587.42 1206.18
587.17 1207.6
586.87 1209.01
586.53 1210.41
586.14 1211.8
585.71 1213.18
585.23 1214.54
584.71 1215.89
584.15 1217.21
583.54 1218.52
582.9 1219.81
582.21 1221.08
581.48 1222.33
580.71 1223.55
579.91 1224.74
579.06 1225.91
578.18 1227.06
577.27 1228.17
576.31 1229.25
575.33 1230.3
574.31 1231.33
573.25 1232.31
572.17 1233.26
571.06 1234.18
569.92 1235.06
568.74 1235.91
567.55 1236.71
566.33 1237.48
565.08 1238.21
563.81 1238.9
562.52 1239.54
561.22 1240.15
559.89 1240.71
558.54 1241.23
557.18 1241.71
555.8 1242.14
554.41 1242.53
553.01 1242.87
551.6 1243.17
550.18 1243.42
548.75 1243.63
547.32 1243.79
545.88 1243.91
544.44 1243.98
543 1244
243 1244
241.24 1244.03
239.48 1244.11
237.72 1244.25
235.97 1244.45
234.22 1244.7
232.49 1245.01
230.76 1245.38
229.05 1245.8
227.35 1246.27
225.67 1246.8
224.01 1247.38
222.36 1248.02
220.74 1248.71
219.14 1249.45
217.56 1250.24
216.01 1251.08
214.49 1251.97
213 1252.9
211.53 1253.89
210.11 1254.92
208.71 1256
207.35 1257.12
206.02 1258.28
204.74 1259.49
203.49 1260.74
202.29 1262.02
201.12 1263.35
200 1264.71
198.92 1266.1
197.89 1267.53
196.91 1269
195.97 1270.49
195.08 1272.01
194.24 1273.56
193.45 1275.14
192.71 1276.74
192.02 1278.36
191.39 1280
190.8 1281.67
190.27 1283.35
189.8 1285.05
189.38 1286.76
189.01 1288.49
188.71 1290.22
188.45 1291.97
188.26 1293.72
188.11 1295.48
188.03 1297.24
188 1299
188.03 1300.76
188.11 1302.52
188.26 1304.28
188.45 1306.03
188.71 1307.78
189.02 1309.51
189.38 1311.24
189.8 1312.95
190.27 1314.65
190.8 1316.33
191.39 1317.99
192.02 1319.64
192.71 1321.26
193.45 1322.86
194.24 1324.44
195.08 1325.99
195.97 1327.51
196.91 1329
197.89 1330.47
198.92 1331.89
200 1333.29
201.12 1334.65
202.29 1335.98
203.49 1337.26
204.74 1338.51
206.02 1339.71
207.35 1340.88
208.71 1342
210.1 1343.08
211.53 1344.11
213 1345.09
214.49 1346.03
216.01 1346.92
217.56 1347.76
219.14 1348.55
220.74 1349.29
222.36 1349.98
224.01 1350.62
225.67 1351.2
227.35 1351.73
229.05 1352.2
230.76 1352.62
232.49 1352.99
234.22 1353.29
235.97 1353.55
237.72 1353.74
239.48 1353.89
241.24 1353.97
243 1354
243.72 1354
244.44 1354.02
245.16 1354.05
245.88 1354.09
246.6 1354.14
247.32 1354.21
248.04 1354.28
248.76 1354.37
249.47 1354.47
250.18 1354.58
250.89 1354.7
251.6 1354.83
252.31 1354.97
253.01 1355.13
253.72 1355.29
254.42 1355.47
255.11 1355.66
255.81 1355.86
256.49 1356.07
257.18 1356.29
257.86 1356.52
258.54 1356.77
259.22 1357.02
259.89 1357.29
260.55 1357.56
261.22 1357.85
261.87 1358.15
262.53 1358.45
263.17 1358.77
263.82 1359.1
264.45 1359.44
265.08 1359.79
265.71 1360.15
266.33 1360.52
266.94 1360.9
267.55 1361.29
268.15 1361.68
268.75 1362.09
269.33 1362.51
269.92 1362.93
270.49 1363.37
271.06 1363.82
271.62 1364.27
272.17 1364.73
272.72 1365.21
273.26 1365.69
273.78 1366.18
274.31 1366.67
274.82 1367.18
275.33 1367.69
275.82 1368.21
276.31 1368.74
276.79 1369.28
277.27 1369.83
277.73 1370.38
278.18 1370.94
278.63 1371.51
279.06 1372.08
279.49 1372.67
279.91 1373.25
280.32 1373.85
280.72 1374.45
281.1 1375.06
281.48 1375.67
281.85 1376.29
282.21 1376.92
282.56 1377.55
282.9 1378.18
283.23 1378.83
283.55 1379.47
283.85 1380.13
284.15 1380.78
284.44 1381.45
284.71 1382.11
284.98 1382.78
285.23 1383.46
285.48 1384.14
285.71 1384.82
285.93 1385.51
286.14 1386.19
286.34 1386.89
286.53 1387.58
286.71 1388.28
286.87 1388.99
287.03 1389.69
287.17 1390.4
287.3 1391.11
287.42 1391.82
287.53 1392.53
287.63 1393.24
287.72 1393.96
287.79 1394.68
287.86 1395.4
287.91 1396.12
287.95 1396.84
287.98 1397.56
287.99 1398.28
288 1399
288 1403.08
288 1407.16
288 1411.24
288 1415.33
288 1419
298 1419
298 1415.33
END
0 97 -1 N 1103 1 1 100 100 0 0 0 Y
582 783.69
582 778.59
582 773.49
582 768.39
582 763.28
582 758.18
582 753.08
582 747.98
582 742.88
582 737.78
582 732.67
582 727.57
582 722.47
582 717.37
582 712.26
582 707.16
582 702.06
582 696.96
582 691.86
582 686.75
582 681.65
582 676.55
582 671.45
582 666.35
582 661.24
582 656.14
582 651.04
582 645.94
582 640.84
582 635.73
582 630.63
582 625.53
582 620.43
582 615.33
582 610.22
582 605.12
582 600.02
582 594.92
582 589.82
582 584.71
582 579.61
582 574.51
582 569.41
582 564.3
582 559.2
582 554.1
582 549
582 543.9
582 538.79
582 533.69
582 528.59
582 523.49
582 518.39
582 513.28
582 508.18
582 503.08
582 497.98
582 492.88
582 487.78
582 482.67
582 477.57
582 472.47
582 467.37
582 462.26
582 457.16
582 452.06
582 446.96
582 441.86
582 436.75
582 431.65
582 426.55
582 421.45
582 416.35
582 411.24
582 406.14
582 401.04
582 395.94
582 390.84
582 385.73
582 380.63
582 375.53
582 370.43
582 365.33
582 360.22
582 355.12
582 350.02
582 344.92
582 339.82
582 334.71
582 329.61
582 324.51
582 319.41
582 316
0 316
0 785
582 785
582 783.69
END
0 189 -1 N 1104 1 1 100 100 0 0 0 Y
598 783.69
598 778.59
598 773.49
598 768.39
598 763.28
598 758.18
598 753.08
598 747.98
598 742.88
598 737.78
598 732.67
598 727.57
598 722.47
598 717.37
598 712.26
598 707.16
598 702.06
598 696.96
598 691.86
598 686.75
598 681.65
598 676.55
598 671.45
598 666.35
598 661.24
598 656.14
598 651.04
598 645.94
598 640.84
598 635.73
598 630.63
598 625.53
598 620.43
598 615.33
598 610.22
598 605.12
598 600.02
598 594.92
598 589.82
598 584.71
598 579.61
598 574.51
598 569.41
598 564.3
598 559.2
598 554.1
598 549
598 543.9
598 538.79
598 533.69
598 528.59
598 523.49
598 518.39
598 513.29
598 508.18
598 503.08
598 497.98
598 492.88
598 487.77
598 482.67
598 477.57
598 472.47
598 467.37
598 462.26
598 457.16
598 452.06
598 446.96
598 441.86
598 436.75
598 431.65
598 426.55
598 421.45
598 416.35
598 411.24
598 406.14
598 401.04
598 395.94
598 390.84
598 385.73
598 380.63
598 375.53
598 370.43
598 365.33
598 360.22
598 355.12
598 350.02
598 344.92
598 339.81
598 334.71
598 329.61
598 324.51
598 319.41
598 316
588 316
588 319.41
588 324.51
588 329.61
588 334.71
588 339.82
588 344.92
588 350.02
588 355.12
588 360.22
588 365.33
588 370.43
588 375.53
588 380.63
588 385.73
588 390.84
588 395.94
588 401.04
588 406.14
588 411.24
588 416.35
588 421.45
588 426.55
588 431.65
588 436.75
588 441.86
588 446.96
588 452.06
588 457.16
588 462.26
588 467.37
588 472.47
588 477.57
588 482.67
588 487.78
588 492.88
588 497.98
588 503.08
588 508.18
588 513.28
588 518.39
588 523.49
588 528.59
588 533.69
588 538.8
588 543.9
588 549
588 554.1
588 559.2
588 564.3
588 569.41
588 574.51
588 579.61
588 584.71
588 589.82
588 594.92
588 600.02
588 605.12
588 610.22
588 615.33
588 620.43
588 625.53
588 630.63
588 635.73
588 640.84
588 645.94
588 651.04
588 656.14
588 661.24
588 666.35
588 671.45
588 676.55
588 681.65
588 686.75
588 691.86
588 696.96
588 702.06
588 707.16
588 712.26
588 717.37
588 722.47
588 727.57
588 732.67
588 737.78
588 742.88
588 747.98
588 753.08
588 758.18
588 763.28
588 768.39
588 773.49
588 778.59
588 783.69
588 785
598 785
598 783.69
END
0 97 -1 N 1105 1 1 100 100 0 0 0 Y
752 316
604 316
604 319.41
604 324.51
604 329.61
604 334.71
604 339.82
604 344.92
604 350.02
604 355.12
604 360.22
604 365.33
604 370.43
604 375.53
604 380.63
604 385.73
604 390.84
604 395.94
604 401.04
604 406.14
604 411.24
604 416.35
604 421.45
604 426.55
604 431.65
604 436.75
604 441.86
604 446.96
604 452.06
604 457.16
604 462.26
604 467.37
604 472.47
604 477.57
604 482.67
604 487.77
604 492.88
604 497.98
604 503.08
604 508.18
604 513.28
604 518.39
604 523.49
604 528.59
604 533.69
604 538.79
604 543.9
604 549
604 554.1
604 559.2
604 564.3
604 569.41
604 574.51
604 579.61
604 584.71
604 589.82
604 594.92
604 600.02
604 605.12
604 610.22
604 615.33
604 620.43
604 625.53
604 630.63
604 635.73
604 640.84
604 645.94
604 651.04
604 656.14
604 661.24
604 666.35
604 671.45
604 676.55
604 681.65
604 686.75
604 691.86
604 696.96
604 702.06
604 707.16
604 712.26
604 717.37
604 722.47
604 727.57
604 732.67
604 737.78
604 742.88
604 747.98
604 753.08
604 758.18
604 763.29
604 768.39
604 773.49
604 778.59
604 783.69
604 785
752 785
752 316
END
0 5 -1 N 1107 1 1 100 100 0 0 0 Y
284 217
0 217
0 227
284 227
284 217
END
0 5 -1 N 1109 1 1 100 100 0 0 0 Y
284 0
0 0
0 211
284 211
284 0
END
0 5 -1 N 1111 1 1 100 100 0 0 0 Y
284 233
0 233
0 316
284 316
284 233
END
0 5 -1 N 1113 1 1 100 100 0 0 0 Y
622 217
284 217
284 227
622 227
622 217
END
0 5 -1 N 1114 1 1 100 100 0 0 0 Y
752 217
622 217
622 227
752 227
752 217
END
0 5 -1 N 1115 1 1 100 100 0 0 0 Y
622 0
284 0
284 211
622 211
622 0
END
0 5 -1 N 1116 1 1 100 100 0 0 0 Y
752 0
622 0
622 211
752 211
752 0
END
0 421 -1 V 1117 1 1 100 100 0 0 0 Y
622 233
284 233
284 316
582 316
582 314.31
582 309.2
582 304.1
582 299
581.99 298.37
581.98 297.75
581.95 297.12
581.92 296.5
581.88 295.88
581.82 295.25
581.76 294.63
581.68 294.01
581.6 293.39
581.5 292.77
581.4 292.16
581.28 291.54
581.16 290.93
581.02 290.32
580.88 289.71
580.72 289.11
580.56 288.5
580.39 287.9
580.2 287.3
580.01 286.71
579.81 286.12
579.6 285.53
579.38 284.95
579.15 284.36
578.91 283.79
578.66 283.21
578.4 282.64
578.14 282.08
577.86 281.52
577.58 280.96
577.28 280.41
576.98 279.86
576.67 279.32
576.35 278.78
576.02 278.25
575.68 277.72
575.34 277.2
574.99 276.69
574.63 276.18
574.26 275.67
573.88 275.17
573.49 274.68
573.1 274.2
572.7 273.72
572.29 273.24
571.87 272.78
571.45 272.32
571.02 271.87
570.58 271.42
570.13 270.98
569.68 270.55
569.22 270.13
568.75 269.71
568.28 269.3
567.8 268.9
567.32 268.51
566.82 268.12
566.33 267.74
565.82 267.37
565.31 267.01
564.8 266.66
564.28 266.31
563.75 265.98
563.22 265.65
562.68 265.33
562.14 265.02
561.59 264.72
561.04 264.42
560.48 264.14
559.92 263.86
559.36 263.6
558.79 263.34
558.21 263.09
557.63 262.85
557.05 262.62
556.47 262.4
555.88 262.19
555.29 261.99
554.69 261.79
554.1 261.61
553.5 261.44
552.89 261.27
552.29 261.12
551.68 260.98
551.07 260.84
550.45 260.72
549.84 260.6
549.22 260.5
548.61 260.4
547.99 260.32
547.37 260.24
546.74 260.18
546.12 260.12
545.5 260.08
544.88 260.04
544.25 260.02
543.63 260
293 260
293 254
543 254
543.72 254.01
544.44 254.02
545.16 254.05
545.88 254.09
546.6 254.14
547.32 254.21
548.04 254.28
548.75 254.37
549.47 254.47
550.18 254.58
550.89 254.7
551.6 254.83
552.31 254.97
553.01 255.13
553.71 255.29
554.41 255.47
555.11 255.66
555.8 255.86
556.49 256.07
557.18 256.29
557.86 256.52
558.54 256.77
559.22 257.02
559.89 257.29
560.55 257.56
561.22 257.85
561.87 258.15
562.52 258.45
563.17 258.77
563.81 259.1
564.45 259.44
565.08 259.79
565.71 260.15
566.33 260.52
566.94 260.9
567.55 261.29
568.15 261.68
568.74 262.09
569.33 262.51
569.92 262.93
570.49 263.37
571.06 263.82
571.62 264.27
572.17 264.73
572.72 265.21
573.25 265.69
573.78 266.18
574.31 266.67
574.82 267.18
575.33 267.69
575.82 268.22
576.31 268.74
576.79 269.28
577.27 269.83
577.73 270.38
578.18 270.94
578.63 271.51
579.06 272.08
579.49 272.67
579.91 273.25
580.32 273.85
580.71 274.45
581.1 275.06
581.48 275.67
581.85 276.29
582.21 276.92
582.56 277.55
582.9 278.18
583.23 278.83
583.54 279.47
583.85 280.13
584.15 280.78
584.44 281.45
584.71 282.11
584.98 282.78
585.23 283.46
585.48 284.14
585.71 284.82
585.93 285.51
586.14 286.2
586.34 286.89
586.53 287.59
586.71 288.28
586.87 288.99
587.03 289.69
587.17 290.4
587.3 291.11
587.42 291.82
587.53 292.53
587.63 293.24
587.72 293.96
587.79 294.68
587.86 295.4
587.91 296.12
587.95 296.84
587.98 297.56
587.99 298.28
588 299
588 304.1
588 309.2
588 314.3
588 316
598 316
598 314.3
598 309.2
598 304.1
598 299
597.99 298.12
597.97 297.24
597.94 296.36
597.89 295.47
597.82 294.6
597.75 293.72
597.65 292.84
597.55 291.97
597.43 291.09
597.3 290.22
597.15 289.35
596.99 288.49
596.81 287.62
596.62 286.76
596.42 285.9
596.2 285.05
595.97 284.2
595.73 283.35
595.47 282.51
595.2 281.67
594.91 280.83
594.62 280
594.31 279.18
593.98 278.36
593.64 277.55
593.29 276.74
592.93 275.93
592.55 275.14
592.16 274.34
591.76 273.56
591.35 272.78
590.92 272.01
590.48 271.24
590.03 270.49
589.57 269.74
589.1 268.99
588.61 268.26
588.11 267.53
587.6 266.81
587.08 266.1
586.54 265.4
586 264.71
585.45 264.02
584.88 263.35
584.3 262.68
583.72 262.02
583.12 261.37
582.51 260.74
581.89 260.11
581.26 259.49
580.62 258.88
579.98 258.28
579.32 257.7
578.65 257.12
577.98 256.55
577.29 256
576.6 255.45
575.9 254.92
575.19 254.4
574.47 253.89
573.74 253.39
573 252.9
572.26 252.43
571.51 251.97
570.75 251.51
569.99 251.08
569.22 250.65
568.44 250.24
567.65 249.83
566.86 249.45
566.07 249.07
565.26 248.71
564.45 248.36
563.64 248.02
562.82 247.69
561.99 247.38
561.17 247.09
560.33 246.8
559.49 246.53
558.65 246.27
557.8 246.03
556.95 245.8
556.1 245.58
555.24 245.38
554.38 245.19
553.51 245.01
552.65 244.85
551.78 244.7
550.91 244.57
550.03 244.45
549.16 244.35
548.28 244.25
547.4 244.18
546.52 244.11
545.64 244.06
544.76 244.03
543.88 244.01
543 244.01
543 244
293 244
293 238
543 238
543.98 238.01
544.95 238.03
545.93 238.07
546.91 238.13
547.88 238.2
548.86 238.28
549.83 238.38
550.8 238.5
551.77 238.63
552.74 238.78
553.7 238.95
554.66 239.12
555.62 239.32
556.57 239.53
557.52 239.76
558.47 239.99
559.42 240.25
560.36 240.52
561.29 240.81
562.22 241.11
563.15 241.42
564.07 241.75
564.98 242.1
565.89 242.46
566.8 242.83
567.69 243.22
568.58 243.62
569.47 244.04
570.34 244.47
571.22 244.92
572.08 245.38
572.93 245.85
573.78 246.34
574.62 246.84
575.45 247.35
576.28 247.88
577.09 248.42
577.9 248.97
578.7 249.53
579.48 250.11
580.26 250.7
581.03 251.31
581.79 251.92
582.54 252.55
583.28 253.19
584.01 253.84
584.73 254.51
585.44 255.18
586.13 255.86
586.82 256.56
587.49 257.27
588.16 257.99
588.81 258.72
589.45 259.46
590.08 260.21
590.69 260.97
591.3 261.73
591.89 262.51
592.47 263.3
593.03 264.1
593.58 264.91
594.12 265.72
594.65 266.54
595.16 267.38
595.66 268.22
596.15 269.07
596.62 269.92
597.08 270.78
597.53 271.65
597.96 272.53
598.38 273.42
598.78 274.31
599.17 275.2
599.54 276.11
599.9 277.02
600.25 277.93
600.58 278.85
600.89 279.78
601.19 280.71
601.48 281.64
601.75 282.58
602.01 283.53
602.24 284.47
602.47 285.42
602.68 286.38
602.88 287.34
603.05 288.3
603.22 289.26
603.37 290.23
603.5 291.2
603.62 292.17
603.72 293.14
603.8 294.12
603.88 295.09
603.93 296.07
603.97 297.04
603.99 298.02
604 299
604 304.1
604 309.2
604 314.3
604 316
622 316
622 233
END
0 8 -1 N 1118 1 1 100 100 0 0 0 Y
752 299
752 260
752 244
752 233
622 233
622 316
752 316
752 299
END
0 5 -1 N 1119 1 1 100 100 0 0 0 Y
152 785
0 785
0 1419
152 1419
152 785
END
0 703 -1 T 1120 1 1 100 100 0 0 0 Y
282 1415.33
282 1411.24
282 1407.16
282 1403.08
282 1399
282 1398.37
281.98 1397.75
281.96 1397.12
281.92 1396.5
281.88 1395.88
281.82 1395.25
281.76 1394.63
281.68 1394.01
281.6 1393.39
281.5 1392.77
281.4 1392.16
281.28 1391.54
281.16 1390.93
281.02 1390.32
280.88 1389.71
280.73 1389.11
280.56 1388.5
280.39 1387.9
280.21 1387.31
280.01 1386.71
279.81 1386.12
279.6 1385.53
279.38 1384.94
279.15 1384.36
278.91 1383.79
278.66 1383.21
278.41 1382.64
278.14 1382.08
277.86 1381.52
277.58 1380.96
277.28 1380.41
276.98 1379.86
276.67 1379.32
276.35 1378.78
276.02 1378.25
275.69 1377.72
275.34 1377.2
274.99 1376.69
274.63 1376.18
274.26 1375.67
273.88 1375.17
273.49 1374.68
273.1 1374.2
272.7 1373.72
272.29 1373.25
271.87 1372.78
271.45 1372.32
271.02 1371.87
270.58 1371.42
270.13 1370.98
269.68 1370.55
269.22 1370.13
268.76 1369.71
268.28 1369.3
267.8 1368.9
267.32 1368.51
266.83 1368.12
266.33 1367.74
265.82 1367.37
265.31 1367.01
264.8 1366.66
264.28 1366.31
263.75 1365.98
263.22 1365.65
262.68 1365.33
262.14 1365.02
261.59 1364.72
261.04 1364.42
260.48 1364.14
259.92 1363.86
259.36 1363.6
258.79 1363.34
258.21 1363.09
257.64 1362.85
257.06 1362.62
256.47 1362.4
255.88 1362.19
255.29 1361.99
254.69 1361.79
254.1 1361.61
253.5 1361.44
252.89 1361.28
252.29 1361.12
251.68 1360.98
251.07 1360.84
250.46 1360.72
249.84 1360.6
249.23 1360.5
248.61 1360.4
247.99 1360.32
247.37 1360.24
246.75 1360.18
246.12 1360.12
245.5 1360.08
244.88 1360.04
244.25 1360.02
243.63 1360
243 1360
241.05 1359.97
239.09 1359.87
237.14 1359.72
235.2 1359.5
233.26 1359.22
231.34 1358.87
229.43 1358.47
227.53 1358
225.64 1357.48
223.78 1356.89
221.93 1356.25
220.11 1355.54
218.31 1354.78
216.53 1353.96
214.79 1353.08
213.07 1352.15
211.38 1351.16
209.72 1350.12
208.1 1349.03
206.52 1347.89
204.97 1346.69
203.46 1345.45
201.99 1344.16
200.56 1342.82
199.18 1341.44
197.84 1340.01
196.55 1338.54
195.31 1337.03
194.11 1335.48
192.97 1333.9
191.88 1332.28
190.84 1330.62
189.85 1328.93
188.92 1327.21
188.04 1325.47
187.22 1323.69
186.46 1321.89
185.75 1320.07
185.11 1318.22
184.52 1316.35
184 1314.47
183.53 1312.57
183.13 1310.66
182.78 1308.74
182.5 1306.8
182.28 1304.86
182.13 1302.91
182.03 1300.95
182 1299
182.03 1297.04
182.13 1295.09
182.28 1293.14
182.5 1291.2
182.78 1289.26
183.13 1287.34
183.53 1285.43
184 1283.53
184.52 1281.64
185.11 1279.78
185.75 1277.93
186.46 1276.11
187.22 1274.31
188.04 1272.53
188.92 1270.78
189.85 1269.07
190.84 1267.38
191.88 1265.72
192.97 1264.1
194.12 1262.51
195.31 1260.97
196.55 1259.46
197.84 1257.99
199.18 1256.56
200.56 1255.18
201.99 1253.84
203.46 1252.55
204.97 1251.31
206.52 1250.11
208.1 1248.97
209.72 1247.88
211.38 1246.84
213.07 1245.85
214.79 1244.92
216.53 1244.04
218.31 1243.22
220.11 1242.46
221.93 1241.75
223.78 1241.11
225.64 1240.52
227.53 1239.99
229.43 1239.53
231.34 1239.12
233.27 1238.78
235.2 1238.5
237.14 1238.28
239.09 1238.12
241.05 1238.03
243 1238
543 1238
544.25 1237.98
545.5 1237.92
546.74 1237.82
547.99 1237.68
549.22 1237.5
550.45 1237.28
551.68 1237.02
552.89 1236.72
554.1 1236.39
555.29 1236.01
556.47 1235.6
557.64 1235.15
558.79 1234.66
559.92 1234.14
561.04 1233.58
562.14 1232.98
563.22 1232.35
564.28 1231.68
565.31 1230.99
566.33 1230.25
567.32 1229.49
568.28 1228.69
569.22 1227.87
570.13 1227.01
571.02 1226.13
571.87 1225.22
572.7 1224.28
573.49 1223.32
574.26 1222.32
574.99 1221.31
575.68 1220.28
576.35 1219.22
576.98 1218.14
577.58 1217.04
578.14 1215.92
578.66 1214.79
579.15 1213.63
579.6 1212.47
580.01 1211.29
580.39 1210.1
580.72 1208.89
581.02 1207.68
581.28 1206.45
581.5 1205.22
581.68 1203.99
581.82 1202.74
581.92 1201.5
581.98 1200.25
582 1199
581.98 1197.75
581.92 1196.5
581.82 1195.25
581.68 1194.01
581.5 1192.78
581.28 1191.54
581.02 1190.32
580.72 1189.11
580.39 1187.9
580.01 1186.71
579.6 1185.53
579.15 1184.36
578.66 1183.21
578.14 1182.08
577.58 1180.96
576.98 1179.86
576.35 1178.78
575.68 1177.72
574.99 1176.69
574.26 1175.67
573.49 1174.68
572.7 1173.72
571.87 1172.78
571.02 1171.87
570.13 1170.98
569.22 1170.13
568.28 1169.3
567.32 1168.51
566.33 1167.74
565.31 1167.01
564.28 1166.31
563.22 1165.65
562.14 1165.02
561.04 1164.42
559.92 1163.86
558.79 1163.34
557.64 1162.85
556.47 1162.4
555.29 1161.99
554.1 1161.61
552.89 1161.27
551.68 1160.98
550.45 1160.72
549.22 1160.5
547.99 1160.32
546.74 1160.18
545.5 1160.08
544.25 1160.02
543 1160
243 1160
241.05 1159.97
239.09 1159.87
237.14 1159.72
235.2 1159.5
233.26 1159.22
231.34 1158.87
229.43 1158.47
227.53 1158
225.65 1157.48
223.78 1156.89
221.93 1156.25
220.11 1155.54
218.31 1154.78
216.53 1153.96
214.79 1153.08
213.07 1152.15
211.38 1151.16
209.72 1150.12
208.1 1149.03
206.52 1147.89
204.97 1146.69
203.46 1145.45
201.99 1144.16
200.56 1142.82
199.18 1141.44
197.84 1140.01
196.55 1138.54
195.31 1137.03
194.11 1135.48
192.97 1133.9
191.88 1132.28
190.84 1130.62
189.85 1128.93
188.92 1127.21
188.04 1125.47
187.22 1123.69
186.46 1121.89
185.75 1120.07
185.11 1118.22
184.52 1116.35
184 1114.47
183.53 1112.57
183.13 1110.66
182.78 1108.73
182.5 1106.8
182.28 1104.86
182.13 1102.91
182.03 1100.95
182 1099
182.03 1097.04
182.13 1095.09
182.28 1093.14
182.5 1091.2
182.78 1089.26
183.13 1087.34
183.53 1085.43
184 1083.53
184.52 1081.64
185.11 1079.78
185.75 1077.93
186.46 1076.11
187.22 1074.31
188.04 1072.53
188.92 1070.78
189.85 1069.07
190.84 1067.38
191.88 1065.72
192.97 1064.1
194.11 1062.51
195.31 1060.97
196.55 1059.46
197.84 1057.99
199.18 1056.56
200.56 1055.18
201.99 1053.84
203.46 1052.55
204.97 1051.31
206.52 1050.11
208.1 1048.97
209.72 1047.88
211.38 1046.83
213.07 1045.85
214.79 1044.92
216.53 1044.04
218.31 1043.22
220.11 1042.46
221.93 1041.75
223.78 1041.11
225.65 1040.52
227.53 1039.99
229.43 1039.53
231.34 1039.12
233.26 1038.78
235.2 1038.5
237.14 1038.28
239.09 1038.12
241.05 1038.03
243 1038
543 1038
544.25 1037.98
545.5 1037.92
546.74 1037.82
547.99 1037.68
549.22 1037.5
550.45 1037.28
551.68 1037.02
552.89 1036.72
554.1 1036.39
555.29 1036.01
556.47 1035.6
557.64 1035.15
558.79 1034.66
559.92 1034.14
561.04 1033.58
562.14 1032.98
563.22 1032.35
564.28 1031.68
565.31 1030.99
566.33 1030.25
567.32 1029.49
568.28 1028.7
569.22 1027.87
570.13 1027.01
571.02 1026.13
571.87 1025.22
572.7 1024.28
573.49 1023.32
574.26 1022.32
574.99 1021.31
575.68 1020.28
576.35 1019.22
576.98 1018.14
577.58 1017.04
578.14 1015.92
578.66 1014.79
579.15 1013.63
579.6 1012.47
580.01 1011.29
580.39 1010.1
580.72 1008.89
581.02 1007.68
581.28 1006.45
581.5 1005.22
581.68 1003.99
581.82 1002.74
581.92 1001.5
581.98 1000.25
582 999
581.98 997.75
581.92 996.5
581.82 995.25
581.68 994.01
581.5 992.78
581.28 991.54
581.02 990.32
580.72 989.11
580.39 987.9
580.01 986.71
579.6 985.53
579.15 984.36
578.66 983.21
578.14 982.08
577.58 980.96
576.98 979.86
576.35 978.78
575.68 977.72
574.99 976.69
574.26 975.67
573.49 974.68
572.7 973.72
571.87 972.78
571.02 971.87
570.13 970.98
569.22 970.13
568.28 969.3
567.32 968.51
566.33 967.74
565.31 967.01
564.28 966.31
563.22 965.65
562.14 965.02
561.04 964.42
559.92 963.86
558.79 963.34
557.63 962.85
556.47 962.4
555.29 961.99
554.1 961.61
552.89 961.28
551.68 960.98
550.45 960.72
549.22 960.5
547.99 960.32
546.75 960.18
545.5 960.08
544.25 960.02
543 960
243 960
241.05 959.97
239.09 959.87
237.14 959.72
235.2 959.5
233.26 959.22
231.34 958.87
229.43 958.47
227.53 958
225.65 957.48
223.78 956.89
221.93 956.25
220.11 955.54
218.31 954.78
216.53 953.96
214.79 953.08
213.07 952.15
211.38 951.16
209.72 950.12
208.1 949.03
206.52 947.89
204.97 946.69
203.46 945.45
201.99 944.16
200.56 942.82
199.18 941.44
197.84 940.01
196.55 938.54
195.31 937.03
194.11 935.48
192.97 933.9
191.88 932.28
190.84 930.62
189.85 928.93
188.92 927.21
188.04 925.47
187.22 923.69
186.46 921.89
185.75 920.07
185.11 918.22
184.52 916.35
184 914.47
183.53 912.57
183.13 910.66
182.78 908.74
182.5 906.8
182.28 904.86
182.13 902.91
182.03 900.95
182 899
182.03 897.04
182.13 895.09
182.28 893.14
182.5 891.2
182.78 889.26
183.13 887.34
183.53 885.42
184 883.53
184.52 881.64
185.11 879.78
185.75 877.93
186.46 876.11
187.22 874.31
188.04 872.53
188.92 870.78
189.85 869.07
190.84 867.38
191.88 865.72
192.97 864.1
194.11 862.51
195.31 860.97
196.55 859.46
197.84 857.99
199.18 856.56
200.56 855.18
201.99 853.84
203.46 852.55
204.97 851.31
206.52 850.11
208.1 848.97
209.72 847.88
211.38 846.83
213.07 845.85
214.79 844.92
216.53 844.04
218.31 843.22
220.11 842.46
221.93 841.75
223.78 841.11
225.65 840.52
227.53 839.99
229.43 839.53
231.34 839.12
233.26 838.78
235.2 838.5
237.14 838.28
239.09 838.12
241.05 838.03
243 838
543 838
543.63 837.99
544.25 837.98
544.88 837.95
545.5 837.92
546.12 837.87
546.74 837.82
547.37 837.75
547.99 837.68
548.61 837.59
549.22 837.5
549.84 837.39
550.45 837.28
551.07 837.15
551.68 837.02
552.29 836.88
552.89 836.72
553.5 836.56
554.1 836.39
554.69 836.2
555.29 836.01
555.88 835.81
556.47 835.6
557.05 835.38
557.64 835.15
558.21 834.91
558.79 834.66
559.36 834.4
559.92 834.14
560.48 833.86
561.04 833.58
561.59 833.28
562.14 832.98
562.68 832.67
563.22 832.35
563.75 832.02
564.28 831.68
564.8 831.34
565.31 830.99
565.82 830.62
566.33 830.25
566.82 829.88
567.32 829.49
567.8 829.1
568.28 828.7
568.75 828.29
569.22 827.87
569.68 827.45
570.13 827.02
570.58 826.58
571.02 826.13
571.45 825.68
571.87 825.22
572.29 824.75
572.7 824.28
573.1 823.8
573.49 823.31
573.88 822.82
574.26 822.32
574.63 821.82
574.99 821.31
575.34 820.8
575.69 820.28
576.02 819.75
576.35 819.22
576.67 818.68
576.98 818.14
577.28 817.59
577.58 817.04
577.86 816.48
578.14 815.92
578.4 815.35
578.66 814.79
578.91 814.21
579.15 813.63
579.38 813.05
579.6 812.47
579.81 811.88
580.01 811.29
580.2 810.69
580.39 810.1
580.56 809.49
580.72 808.89
580.88 808.29
581.02 807.68
581.16 807.07
581.28 806.45
581.4 805.84
581.5 805.22
581.6 804.61
581.68 803.99
581.75 803.37
581.82 802.74
581.88 802.12
581.92 801.5
581.95 800.87
581.98 800.25
581.99 799.62
582 799
582 793.9
582 788.8
582 785
152 785
152 1419
282 1419
282 1415.33
END
0 703 -1 N 1121 1 1 100 100 0 0 0 Y
632 785
604 785
604 788.79
604 793.9
604 799
603.99 799.98
603.97 800.95
603.93 801.93
603.87 802.91
603.8 803.88
603.72 804.86
603.62 805.83
603.5 806.8
603.37 807.77
603.22 808.74
603.05 809.7
602.88 810.66
602.68 811.62
602.47 812.57
602.24 813.52
602.01 814.47
601.75 815.42
601.48 816.35
601.19 817.29
600.89 818.22
600.58 819.15
600.25 820.07
599.9 820.98
599.54 821.89
599.17 822.79
598.78 823.69
598.38 824.58
597.96 825.47
597.53 826.34
597.08 827.21
596.62 828.08
596.15 828.93
595.66 829.78
595.16 830.62
594.65 831.45
594.12 832.28
593.58 833.09
593.03 833.9
592.46 834.7
591.89 835.48
591.3 836.26
590.69 837.03
590.08 837.79
589.45 838.54
588.81 839.28
588.16 840.01
587.49 840.73
586.82 841.44
586.13 842.13
585.44 842.82
584.73 843.49
584.01 844.16
583.28 844.81
582.54 845.45
581.79 846.07
581.03 846.69
580.26 847.29
579.48 847.89
578.7 848.46
577.9 849.03
577.09 849.58
576.28 850.12
575.45 850.65
574.62 851.16
573.78 851.66
572.93 852.15
572.08 852.62
571.22 853.08
570.34 853.53
569.47 853.96
568.58 854.37
567.69 854.78
566.8 855.17
565.89 855.54
564.98 855.9
564.07 856.25
563.15 856.58
562.22 856.89
561.29 857.19
560.36 857.48
559.42 857.75
558.47 858
557.52 858.24
556.57 858.47
555.62 858.68
554.66 858.87
553.7 859.05
552.74 859.22
551.77 859.36
550.8 859.5
549.83 859.61
548.86 859.72
547.88 859.8
546.91 859.87
545.93 859.93
544.95 859.97
543.98 859.99
543 860
243 860
241.75 860.02
240.5 860.08
239.26 860.18
238.01 860.32
236.78 860.5
235.55 860.72
234.32 860.98
233.11 861.28
231.9 861.61
230.71 861.99
229.53 862.4
228.37 862.85
227.21 863.34
226.08 863.86
224.96 864.42
223.86 865.02
222.78 865.65
221.72 866.31
220.69 867.01
219.67 867.74
218.68 868.51
217.72 869.3
216.78 870.13
215.87 870.98
214.99 871.87
214.13 872.78
213.31 873.72
212.51 874.68
211.75 875.67
211.01 876.69
210.32 877.72
209.65 878.78
209.02 879.86
208.42 880.96
207.86 882.08
207.34 883.21
206.85 884.36
206.4 885.53
205.99 886.71
205.61 887.9
205.28 889.11
204.98 890.32
204.72 891.54
204.5 892.78
204.32 894.01
204.18 895.25
204.08 896.5
204.02 897.75
204 899
204.02 900.25
204.08 901.5
204.18 902.74
204.32 903.99
204.5 905.22
204.72 906.45
204.98 907.68
205.28 908.89
205.61 910.1
205.99 911.29
206.4 912.47
206.85 913.63
207.34 914.79
207.86 915.92
208.42 917.04
209.02 918.14
209.65 919.22
210.32 920.28
211.01 921.31
211.75 922.32
212.51 923.32
213.31 924.28
214.13 925.22
214.99 926.13
215.87 927.01
216.78 927.87
217.72 928.7
218.69 929.49
219.67 930.25
220.69 930.99
221.73 931.68
222.78 932.35
223.86 932.98
224.96 933.58
226.08 934.14
227.21 934.66
228.37 935.15
229.53 935.6
230.71 936.01
231.9 936.39
233.11 936.72
234.32 937.02
235.55 937.28
236.78 937.5
238.01 937.68
239.26 937.82
240.5 937.92
241.75 937.98
243 938
543 938
544.95 938.03
546.91 938.12
548.86 938.28
550.8 938.5
552.74 938.78
554.66 939.12
556.57 939.53
558.47 939.99
560.36 940.52
562.22 941.11
564.07 941.75
565.89 942.46
567.69 943.22
569.47 944.04
571.22 944.92
572.93 945.85
574.62 946.83
576.28 947.88
577.9 948.97
579.49 950.11
581.03 951.31
582.54 952.55
584.01 953.84
585.44 955.18
586.82 956.56
588.16 957.99
589.45 959.46
590.69 960.97
591.89 962.51
593.03 964.1
594.12 965.72
595.16 967.38
596.15 969.07
597.08 970.78
597.96 972.53
598.78 974.31
599.54 976.11
600.25 977.93
600.89 979.78
601.48 981.64
602.01 983.53
602.47 985.43
602.88 987.34
603.22 989.26
603.5 991.2
603.72 993.14
603.88 995.09
603.97 997.04
604 999
603.97 1000.95
603.87 1002.91
603.72 1004.86
603.5 1006.8
603.22 1008.73
602.88 1010.66
602.47 1012.57
602.01 1014.47
601.48 1016.36
600.89 1018.22
600.25 1020.07
599.54 1021.89
598.78 1023.69
597.96 1025.47
597.08 1027.21
596.15 1028.93
595.16 1030.62
594.12 1032.28
593.03 1033.9
591.89 1035.48
590.69 1037.03
589.45 1038.54
588.16 1040.01
586.82 1041.44
585.44 1042.82
584.01 1044.16
582.54 1045.45
581.03 1046.69
579.49 1047.89
577.9 1049.03
576.28 1050.12
574.62 1051.16
572.93 1052.15
571.22 1053.08
569.47 1053.96
567.69 1054.78
565.89 1055.54
564.07 1056.25
562.22 1056.89
560.36 1057.48
558.47 1058
556.57 1058.47
554.66 1058.87
552.74 1059.22
550.8 1059.5
548.86 1059.72
546.91 1059.87
544.95 1059.97
543 1060
243 1060
241.75 1060.02
240.5 1060.08
239.26 1060.18
238.01 1060.32
236.78 1060.5
235.55 1060.72
234.32 1060.98
233.11 1061.27
231.9 1061.61
230.71 1061.99
229.53 1062.4
228.37 1062.85
227.21 1063.34
226.08 1063.86
224.96 1064.42
223.86 1065.02
222.78 1065.65
221.73 1066.31
220.69 1067.01
219.67 1067.74
218.69 1068.51
217.72 1069.3
216.78 1070.13
215.87 1070.98
214.99 1071.87
214.13 1072.78
213.31 1073.72
212.51 1074.68
211.75 1075.67
211.01 1076.69
210.32 1077.72
209.65 1078.78
209.02 1079.86
208.42 1080.96
207.86 1082.08
207.34 1083.21
206.85 1084.36
206.4 1085.53
205.99 1086.71
205.61 1087.9
205.28 1089.11
204.98 1090.32
204.72 1091.54
204.5 1092.78
204.32 1094.01
204.18 1095.25
204.08 1096.5
204.02 1097.75
204 1099
204.02 1100.25
204.08 1101.5
204.18 1102.74
204.32 1103.99
204.5 1105.22
204.72 1106.45
204.98 1107.68
205.28 1108.89
205.61 1110.1
205.99 1111.29
206.4 1112.47
206.85 1113.63
207.34 1114.79
207.86 1115.92
208.42 1117.04
209.02 1118.14
209.65 1119.22
210.32 1120.28
211.01 1121.31
211.75 1122.32
212.51 1123.32
213.3 1124.28
214.13 1125.22
214.99 1126.13
215.87 1127.01
216.78 1127.87
217.72 1128.7
218.69 1129.49
219.67 1130.25
220.69 1130.99
221.72 1131.68
222.78 1132.35
223.86 1132.98
224.96 1133.58
226.08 1134.14
227.21 1134.66
228.37 1135.15
229.53 1135.6
230.71 1136.01
231.9 1136.39
233.11 1136.72
234.32 1137.02
235.55 1137.28
236.78 1137.5
238.01 1137.68
239.26 1137.82
240.5 1137.92
241.75 1137.98
243 1138
543 1138
544.95 1138.03
546.91 1138.12
548.86 1138.28
550.8 1138.5
552.74 1138.78
554.66 1139.12
556.57 1139.53
558.47 1139.99
560.36 1140.52
562.22 1141.11
564.07 1141.75
565.89 1142.46
567.69 1143.22
569.47 1144.04
571.21 1144.92
572.93 1145.85
574.62 1146.84
576.28 1147.88
577.9 1148.97
579.48 1150.11
581.03 1151.31
582.54 1152.55
584.01 1153.84
585.44 1155.18
586.82 1156.56
588.16 1157.99
589.45 1159.46
590.69 1160.97
591.89 1162.51
593.03 1164.1
594.12 1165.72
595.16 1167.38
596.15 1169.07
597.08 1170.78
597.96 1172.53
598.78 1174.31
599.54 1176.11
600.25 1177.93
600.89 1179.78
601.48 1181.64
602.01 1183.53
602.47 1185.43
602.88 1187.34
603.22 1189.26
603.5 1191.2
603.72 1193.14
603.88 1195.09
603.97 1197.04
604 1199
603.97 1200.95
603.88 1202.91
603.72 1204.86
603.5 1206.8
603.22 1208.74
602.88 1210.66
602.47 1212.57
602.01 1214.47
601.48 1216.35
600.89 1218.22
600.25 1220.07
599.54 1221.89
598.78 1223.69
597.96 1225.47
597.08 1227.21
596.15 1228.93
595.16 1230.62
594.12 1232.28
593.03 1233.9
591.89 1235.48
590.69 1237.03
589.45 1238.54
588.16 1240.01
586.82 1241.44
585.44 1242.82
584.01 1244.16
582.54 1245.45
581.03 1246.69
579.48 1247.89
577.9 1249.03
576.28 1250.12
574.62 1251.16
572.93 1252.15
571.22 1253.08
569.47 1253.96
567.69 1254.78
565.89 1255.54
564.07 1256.25
562.22 1256.89
560.36 1257.48
558.47 1258
556.57 1258.47
554.66 1258.87
552.74 1259.22
550.8 1259.5
548.86 1259.72
546.91 1259.87
544.95 1259.97
543 1260
243 1260
241.75 1260.02
240.5 1260.08
239.26 1260.18
238.01 1260.32
236.78 1260.5
235.55 1260.72
234.32 1260.98
233.11 1261.27
231.9 1261.61
230.71 1261.99
229.53 1262.4
228.37 1262.85
227.21 1263.34
226.08 1263.86
224.96 1264.42
223.86 1265.02
222.78 1265.65
221.72 1266.31
220.69 1267.01
219.67 1267.74
218.68 1268.51
217.72 1269.3
216.78 1270.13
215.87 1270.98
214.99 1271.87
214.13 1272.78
213.3 1273.72
212.51 1274.68
211.75 1275.67
211.01 1276.69
210.32 1277.72
209.65 1278.78
209.02 1279.86
208.42 1280.96
207.86 1282.08
207.34 1283.21
206.85 1284.36
206.4 1285.53
205.99 1286.71
205.61 1287.9
205.28 1289.11
204.98 1290.32
204.72 1291.54
204.5 1292.78
204.32 1294.01
204.18 1295.25
204.08 1296.5
204.02 1297.75
204 1299
204.02 1300.25
204.08 1301.5
204.18 1302.74
204.32 1303.99
204.5 1305.22
204.72 1306.45
204.98 1307.68
205.28 1308.89
205.61 1310.1
205.99 1311.29
206.4 1312.47
206.85 1313.63
207.34 1314.79
207.86 1315.92
208.42 1317.04
209.02 1318.14
209.65 1319.22
210.32 1320.27
211.01 1321.31
211.75 1322.32
212.51 1323.31
213.31 1324.28
214.13 1325.22
214.99 1326.13
215.87 1327.02
216.78 1327.87
217.72 1328.69
218.69 1329.49
219.68 1330.25
220.69 1330.99
221.73 1331.68
222.78 1332.35
223.86 1332.98
224.96 1333.58
226.08 1334.14
227.21 1334.66
228.37 1335.15
229.53 1335.6
230.71 1336.01
231.9 1336.39
233.11 1336.72
234.32 1337.02
235.55 1337.28
236.78 1337.5
238.01 1337.68
239.26 1337.82
240.5 1337.92
241.75 1337.98
243 1338
243.98 1338.01
244.96 1338.03
245.93 1338.07
246.91 1338.12
247.88 1338.19
248.86 1338.28
249.83 1338.38
250.8 1338.5
251.77 1338.63
252.74 1338.78
253.7 1338.94
254.66 1339.12
255.62 1339.32
256.58 1339.53
257.53 1339.75
258.47 1339.99
259.42 1340.25
260.36 1340.52
261.29 1340.81
262.22 1341.11
263.15 1341.42
264.07 1341.75
264.98 1342.1
265.89 1342.46
266.8 1342.83
267.69 1343.22
268.58 1343.62
269.47 1344.04
270.34 1344.47
271.22 1344.92
272.08 1345.38
272.93 1345.85
273.78 1346.33
274.62 1346.84
275.45 1347.35
276.28 1347.88
277.09 1348.42
277.9 1348.97
278.7 1349.53
279.49 1350.11
280.27 1350.7
281.03 1351.31
281.79 1351.92
282.54 1352.55
283.28 1353.19
284.01 1353.84
284.73 1354.51
285.44 1355.18
286.14 1355.87
286.82 1356.56
287.49 1357.27
288.16 1357.99
288.81 1358.72
289.45 1359.46
290.08 1360.21
290.69 1360.97
291.3 1361.73
291.89 1362.51
292.47 1363.3
293.03 1364.1
293.58 1364.91
294.12 1365.72
294.65 1366.54
295.16 1367.38
295.66 1368.22
296.15 1369.07
296.62 1369.92
297.08 1370.78
297.53 1371.66
297.96 1372.53
298.38 1373.42
298.78 1374.31
299.17 1375.2
299.54 1376.11
299.9 1377.02
300.25 1377.93
300.58 1378.85
300.89 1379.78
301.19 1380.71
301.48 1381.64
301.75 1382.58
302.01 1383.53
302.24 1384.47
302.47 1385.42
302.68 1386.38
302.88 1387.34
303.05 1388.3
303.22 1389.26
303.37 1390.23
303.5 1391.2
303.62 1392.17
303.72 1393.14
303.8 1394.12
303.88 1395.09
303.93 1396.07
303.97 1397.04
303.99 1398.02
304 1399
304 1403.08
304 1407.16
304 1411.24
304 1415.33
304 1419
632 1419
632 785
END
0 6 -1 N 1122 1 1 100 100 0 0 0 Y
752 799
752 785
632 785
632 1419
752 1419
752 799
END
END GEO
OPT
MAX 100
VARS
END
END OPT
VARSWP
END VARSWP
```
