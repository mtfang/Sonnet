Readout.son:
```
FTYP SONPROJ 15 ! Sonnet Project File
VER 16.52
HEADER
LIC calt2.2.43068 b6ae2bd1257f DESKTOP-SL82IK9 Michael
DAT 07/21/2016 09:42:36
BUILT_BY_CREATED xgeom 16.52 04/11/2016 14:48:12
BUILT_BY_SAVED xgeom 16.52
MDATE 07/21/2016 09:42:36
HDATE 07/21/2016 09:42:23
END HEADER
DIM
FREQ GHZ
IND NH
LNG UM
ANG DEG
CON /OH
CAP PF
RES OH
END DIM
FREQ
ABS 6.0 8.0 
END FREQ
CONTROL
ABS
OPTIONS  -dj 
SPEED 0
CACHE_ABS 1
TARG_ABS 300
Q_ACC Y
DET_ABS_RES Y
END CONTROL
GEO
TMET "Lossless" 0 SUP 0 0 0 0
BMET "Lossless" 0 SUP 0 0 0 0
MET "Unknown_metal" 1 NOR INF 0 0 
BOX 1 546 2112 546 2112 20 0
      1000 1 1 0 0 0 0 "Unnamed"
      500 11.9 1 5e-006 0 0 0 "Silicon (intrinsic)"
LORGN 0 2112 U 
POR1 STD
POLY 1953 1
1
1 50 0 0 0 -1.642119633e-005 80 
POR1 STD
POLY 1953 1
3
2 50 0 0 0 546 80 
NUM 17
0 5 -1 N 1917 1 1 100 100 0 0 0 Y
180 1777
155.999996 1777
155.999996 2111.999971
180 2111.999971
180 1777
END
0 5 -1 N 1953 1 1 100 100 0 0 0 Y
546 75
-1.642119633e-005 75
-1.642119633e-005 85
546 85
546 75
END
0 5 -1 N 1954 1 1 100 100 0 0 0 Y
546 -2
1.000045649 -2
1.000045649 69.00000437
546 69.00000437
546 -2
END
0 13 -1 N 1959 1 1 100 100 0 0 0 Y
412 118
218 118
218 112
412 112
412 102
218 102
218 96
412 96
412 91
1 91
1 176
412 176
412 118
END
0 105 -1 T 1960 1 1 100 100 0 0 0 Y
457 172.3
457 167.2
457 162.1
457 157
456.99 156.37
456.98 155.75
456.95 155.12
456.92 154.5
456.88 153.88
456.82 153.25
456.76 152.63
456.68 152.01
456.6 151.39
456.5 150.78
456.4 150.16
456.28 149.54
456.16 148.93
456.02 148.32
455.88 147.71
455.72 147.11
455.56 146.5
455.39 145.9
455.2 145.3
455.01 144.71
454.81 144.12
454.6 143.53
454.38 142.95
454.15 142.36
453.91 141.79
453.66 141.21
453.4 140.64
453.14 140.08
452.86 139.52
452.58 138.96
452.28 138.41
451.98 137.86
451.67 137.32
451.35 136.78
451.02 136.25
450.69 135.72
450.34 135.2
449.99 134.69
449.63 134.18
449.26 133.67
448.88 133.18
448.49 132.68
448.1 132.2
447.7 131.72
447.29 131.24
446.87 130.78
446.45 130.32
446.02 129.87
445.58 129.42
445.13 128.98
444.68 128.55
444.22 128.13
443.75 127.71
443.28 127.3
442.8 126.9
442.32 126.51
441.82 126.12
441.33 125.74
440.82 125.37
440.31 125.01
439.8 124.66
439.28 124.31
438.75 123.98
438.22 123.65
437.68 123.33
437.14 123.02
436.59 122.72
436.04 122.42
435.48 122.14
434.92 121.86
434.36 121.6
433.79 121.34
433.21 121.09
432.64 120.85
432.05 120.62
431.47 120.4
430.88 120.19
430.29 119.99
429.69 119.79
429.1 119.61
428.5 119.44
427.89 119.27
427.29 119.12
426.68 118.98
426.07 118.84
425.45 118.72
424.84 118.6
424.22 118.5
423.61 118.4
422.99 118.32
422.37 118.24
421.74 118.18
421.12 118.12
420.5 118.08
419.88 118.04
419.25 118.02
418.63 118
412 118
412 176
457 176
457 172.3
END
0 210 -1 V 1961 1 1 100 100 0 0 0 Y
473 172.3
473 167.2
473 162.1
473 157
472.99 156.12
472.97 155.24
472.94 154.35
472.89 153.47
472.82 152.6
472.75 151.72
472.65 150.84
472.55 149.97
472.43 149.09
472.3 148.22
472.15 147.35
471.99 146.49
471.81 145.62
471.62 144.76
471.42 143.9
471.2 143.05
470.97 142.2
470.73 141.35
470.47 140.51
470.2 139.67
469.91 138.83
469.62 138
469.31 137.18
468.98 136.36
468.64 135.54
468.29 134.74
467.93 133.93
467.55 133.13
467.16 132.34
466.76 131.56
466.35 130.78
465.92 130.01
465.48 129.24
465.03 128.49
464.57 127.74
464.1 126.99
463.61 126.26
463.11 125.53
462.6 124.81
462.08 124.1
461.55 123.4
461 122.71
460.45 122.02
459.88 121.35
459.3 120.68
458.72 120.02
458.12 119.38
457.51 118.74
456.89 118.11
456.26 117.49
455.62 116.88
454.98 116.28
454.32 115.7
453.65 115.12
452.98 114.55
452.29 114
451.6 113.45
450.9 112.92
450.19 112.4
449.47 111.89
448.74 111.39
448 110.9
447.26 110.43
446.51 109.97
445.75 109.51
444.99 109.08
444.22 108.65
443.44 108.24
442.65 107.84
441.86 107.45
441.07 107.07
440.26 106.71
439.45 106.36
438.64 106.02
437.82 105.7
436.99 105.38
436.17 105.09
435.33 104.8
434.49 104.53
433.65 104.27
432.8 104.03
431.95 103.8
431.1 103.58
430.24 103.38
429.38 103.19
428.51 103.01
427.65 102.85
426.78 102.7
425.91 102.57
425.03 102.45
424.16 102.35
423.28 102.25
422.4 102.18
421.52 102.11
420.64 102.06
419.76 102.03
418.88 102.01
418 102.01
418 102
412 102
412 112
418 112
418.72 112.01
419.44 112.02
420.16 112.05
420.88 112.09
421.6 112.14
422.32 112.21
423.04 112.28
423.75 112.37
424.47 112.47
425.18 112.58
425.89 112.7
426.6 112.83
427.31 112.97
428.01 113.13
428.72 113.29
429.41 113.47
430.11 113.66
430.8 113.86
431.49 114.07
432.18 114.29
432.86 114.52
433.54 114.77
434.22 115.02
434.89 115.29
435.55 115.56
436.22 115.85
436.87 116.15
437.52 116.45
438.17 116.77
438.81 117.1
439.45 117.44
440.08 117.79
440.71 118.15
441.33 118.52
441.94 118.9
442.55 119.28
443.15 119.68
443.74 120.09
444.33 120.51
444.92 120.93
445.49 121.37
446.06 121.82
446.62 122.27
447.17 122.73
447.72 123.21
448.25 123.69
448.78 124.18
449.31 124.67
449.82 125.18
450.33 125.69
450.82 126.21
451.31 126.74
451.79 127.28
452.27 127.83
452.73 128.38
453.18 128.94
453.63 129.51
454.06 130.08
454.49 130.67
454.91 131.25
455.32 131.85
455.71 132.45
456.1 133.06
456.48 133.67
456.85 134.29
457.21 134.92
457.56 135.55
457.9 136.18
458.23 136.83
458.54 137.47
458.85 138.13
459.15 138.78
459.44 139.45
459.71 140.11
459.98 140.78
460.23 141.46
460.48 142.14
460.71 142.82
460.93 143.51
461.14 144.2
461.34 144.89
461.53 145.58
461.71 146.28
461.87 146.99
462.03 147.69
462.17 148.4
462.3 149.11
462.42 149.82
462.53 150.53
462.63 151.24
462.72 151.96
462.79 152.68
462.86 153.4
462.91 154.12
462.95 154.84
462.98 155.56
462.99 156.28
463 157
463 162.1
463 167.2
463 172.3
463 176
473 176
473 172.3
END
0 108 -1 T 1963 1 1 100 100 0 0 0 Y
490 91
412 91
412 96
418 96
418.98 96.01
419.95 96.03
420.93 96.07
421.91 96.13
422.88 96.2
423.86 96.28
424.83 96.38
425.8 96.5
426.77 96.63
427.74 96.78
428.7 96.95
429.66 97.13
430.62 97.32
431.57 97.53
432.52 97.75
433.47 97.99
434.42 98.25
435.36 98.52
436.29 98.81
437.22 99.11
438.15 99.42
439.07 99.75
439.98 100.1
440.89 100.46
441.8 100.83
442.69 101.22
443.58 101.62
444.47 102.04
445.34 102.47
446.22 102.92
447.08 103.38
447.93 103.85
448.78 104.34
449.62 104.84
450.45 105.35
451.28 105.88
452.09 106.42
452.9 106.97
453.7 107.53
454.48 108.11
455.26 108.7
456.03 109.31
456.79 109.92
457.54 110.55
458.28 111.19
459.01 111.84
459.73 112.51
460.44 113.18
461.13 113.86
461.82 114.56
462.49 115.27
463.16 115.99
463.81 116.72
464.45 117.46
465.08 118.21
465.69 118.97
466.3 119.74
466.89 120.51
467.47 121.3
468.03 122.1
468.58 122.91
469.12 123.72
469.65 124.54
470.16 125.38
470.66 126.22
471.15 127.07
471.62 127.92
472.08 128.78
472.53 129.66
472.96 130.53
473.38 131.42
473.78 132.31
474.17 133.2
474.54 134.11
474.9 135.02
475.25 135.93
475.58 136.85
475.89 137.78
476.19 138.71
476.48 139.64
476.75 140.58
477.01 141.53
477.25 142.47
477.47 143.43
477.68 144.38
477.88 145.34
478.05 146.3
478.22 147.26
478.37 148.23
478.5 149.2
478.62 150.17
478.72 151.14
478.8 152.12
478.88 153.09
478.93 154.07
478.97 155.04
478.99 156.02
479 157
479 162.1
479 167.2
479 172.31
479 176
490 176
490 91
END
0 6 -1 N 1964 1 1 100 100 0 0 0 Y
546 157
546 91
490 91
490 176
546 176
546 157
END
0 99 -1 N 1965 1 1 100 100 0 0 0 Y
457 651.9
457 646.79
457 641.69
457 636.59
457 631.49
457 626.39
457 621.28
457 616.18
457 611.08
457 605.98
457 600.88
457 595.78
457 590.67
457 585.57
457 580.47
457 575.37
457 570.26
457 565.16
457 560.06
457 554.96
457 549.86
457 544.75
457 539.65
457 534.55
457 529.45
457 524.35
457 519.24
457 514.14
457 509.04
457 503.94
457 498.84
457 493.73
457 488.63
457 483.53
457 478.43
457 473.33
457 468.22
457 463.12
457 458.02
457 452.92
457 447.82
457 442.71
457 437.61
457 432.51
457 427.41
457 422.3
457 417.2
457 412.1
457 407
457 401.9
457 396.8
457 391.69
457 386.59
457 381.49
457 376.39
457 371.28
457 366.18
457 361.08
457 355.98
457 350.88
457 345.78
457 340.67
457 335.57
457 330.47
457 325.37
457 320.26
457 315.16
457 310.06
457 304.96
457 299.86
457 294.75
457 289.65
457 284.55
457 279.45
457 274.35
457 269.24
457 264.14
457 259.04
457 253.94
457 248.84
457 243.73
457 238.63
457 233.53
457 228.43
457 223.33
457 218.22
457 213.12
457 208.02
457 202.92
457 197.82
457 192.71
457 187.61
457 182.51
457 177.41
457 176
1 176
1 653
457 653
457 651.9
END
0 193 -1 N 1967 1 1 100 100 0 0 0 Y
473 651.9
473 646.79
473 641.69
473 636.59
473 631.49
473 626.39
473 621.28
473 616.18
473 611.08
473 605.98
473 600.88
473 595.78
473 590.67
473 585.57
473 580.47
473 575.37
473 570.26
473 565.16
473 560.06
473 554.96
473 549.86
473 544.75
473 539.65
473 534.55
473 529.45
473 524.35
473 519.24
473 514.14
473 509.04
473 503.94
473 498.84
473 493.73
473 488.63
473 483.53
473 478.43
473 473.33
473 468.22
473 463.12
473 458.02
473 452.92
473 447.82
473 442.71
473 437.61
473 432.51
473 427.41
473 422.3
473 417.2
473 412.1
473 407
473 401.9
473 396.8
473 391.69
473 386.59
473 381.49
473 376.39
473 371.28
473 366.18
473 361.08
473 355.98
473 350.88
473 345.78
473 340.67
473 335.57
473 330.47
473 325.37
473 320.26
473 315.16
473 310.06
473 304.96
473 299.86
473 294.75
473 289.65
473 284.55
473 279.45
473 274.35
473 269.24
473 264.14
473 259.04
473 253.94
473 248.84
473 243.73
473 238.63
473 233.53
473 228.43
473 223.33
473 218.22
473 213.12
473 208.02
473 202.92
473 197.82
473 192.71
473 187.61
473 182.51
473 177.41
473 176
463 176
463 177.41
463 182.51
463 187.61
463 192.71
463 197.82
463 202.92
463 208.02
463 213.12
463 218.22
463 223.33
463 228.43
463 233.53
463 238.63
463 243.73
463 248.84
463 253.94
463 259.04
463 264.14
463 269.24
463 274.35
463 279.45
463 284.55
463 289.65
463 294.75
463 299.86
463 304.96
463 310.06
463 315.16
463 320.26
463 325.37
463 330.47
463 335.57
463 340.67
463 345.78
463 350.88
463 355.98
463 361.08
463 366.18
463 371.28
463 376.39
463 381.49
463 386.59
463 391.69
463 396.79
463 401.9
463 407
463 412.1
463 417.2
463 422.3
463 427.41
463 432.51
463 437.61
463 442.71
463 447.82
463 452.92
463 458.02
463 463.12
463 468.22
463 473.33
463 478.43
463 483.53
463 488.63
463 493.73
463 498.84
463 503.94
463 509.04
463 514.14
463 519.24
463 524.35
463 529.45
463 534.55
463 539.65
463 544.75
463 549.86
463 554.96
463 560.06
463 565.16
463 570.26
463 575.37
463 580.47
463 585.57
463 590.67
463 595.78
463 600.88
463 605.98
463 611.08
463 616.18
463 621.28
463 626.39
463 631.49
463 636.59
463 641.69
463 646.79
463 651.9
463 653
473 653
473 651.9
END
0 99 -1 N 1969 1 1 100 100 0 0 0 Y
546 176
479 176
479 177.41
479 182.51
479 187.61
479 192.71
479 197.82
479 202.92
479 208.02
479 213.12
479 218.22
479 223.33
479 228.43
479 233.53
479 238.63
479 243.73
479 248.84
479 253.94
479 259.04
479 264.14
479 269.24
479 274.35
479 279.45
479 284.55
479 289.65
479 294.75
479 299.86
479 304.96
479 310.06
479 315.16
479 320.26
479 325.37
479 330.47
479 335.57
479 340.67
479 345.78
479 350.88
479 355.98
479 361.08
479 366.18
479 371.28
479 376.39
479 381.49
479 386.59
479 391.69
479 396.79
479 401.9
479 407
479 412.1
479 417.2
479 422.3
479 427.41
479 432.51
479 437.61
479 442.71
479 447.82
479 452.92
479 458.02
479 463.12
479 468.22
479 473.33
479 478.43
479 483.53
479 488.63
479 493.73
479 498.84
479 503.94
479 509.04
479 514.14
479 519.24
479 524.35
479 529.45
479 534.55
479 539.65
479 544.75
479 549.86
479 554.96
479 560.06
479 565.16
479 570.26
479 575.37
479 580.47
479 585.57
479 590.67
479 595.78
479 600.88
479 605.98
479 611.08
479 616.18
479 621.29
479 626.39
479 631.49
479 636.59
479 641.69
479 646.8
479 651.9
479 653
546 653
546 176
END
0 703 -1 T 1971 1 1 100 100 0 0 0 Y
157 1270.78
157 1266.18
157 1261.59
157 1257
157 1256.37
156.98 1255.75
156.96 1255.12
156.92 1254.5
156.88 1253.88
156.82 1253.25
156.76 1252.63
156.68 1252.01
156.6 1251.39
156.5 1250.78
156.4 1250.16
156.28 1249.54
156.16 1248.93
156.02 1248.32
155.88 1247.71
155.73 1247.11
155.56 1246.5
155.39 1245.9
155.21 1245.31
155.01 1244.71
154.81 1244.12
154.6 1243.53
154.38 1242.94
154.15 1242.36
153.91 1241.79
153.66 1241.21
153.41 1240.64
153.14 1240.08
152.86 1239.52
152.58 1238.96
152.28 1238.41
151.98 1237.86
151.67 1237.32
151.35 1236.78
151.02 1236.25
150.69 1235.72
150.34 1235.2
149.99 1234.69
149.63 1234.18
149.26 1233.67
148.88 1233.17
148.49 1232.68
148.1 1232.2
147.7 1231.72
147.29 1231.24
146.87 1230.78
146.45 1230.32
146.02 1229.87
145.58 1229.42
145.13 1228.98
144.68 1228.55
144.22 1228.13
143.76 1227.71
143.28 1227.3
142.8 1226.9
142.32 1226.51
141.83 1226.12
141.33 1225.74
140.82 1225.37
140.31 1225.01
139.8 1224.66
139.28 1224.31
138.75 1223.98
138.22 1223.65
137.68 1223.33
137.14 1223.02
136.59 1222.71
136.04 1222.42
135.48 1222.14
134.92 1221.86
134.36 1221.6
133.79 1221.34
133.21 1221.09
132.64 1220.85
132.06 1220.62
131.47 1220.4
130.88 1220.19
130.29 1219.99
129.69 1219.79
129.1 1219.61
128.5 1219.44
127.89 1219.28
127.29 1219.12
126.68 1218.98
126.07 1218.84
125.46 1218.72
124.84 1218.6
124.22 1218.5
123.61 1218.4
122.99 1218.32
122.37 1218.24
121.75 1218.18
121.12 1218.12
120.5 1218.08
119.88 1218.04
119.25 1218.02
118.63 1218
118 1218
116.05 1217.97
114.09 1217.87
112.14 1217.72
110.2 1217.5
108.26 1217.22
106.34 1216.87
104.43 1216.47
102.53 1216
100.65 1215.48
98.78 1214.89
96.93 1214.25
95.11 1213.54
93.31 1212.78
91.53 1211.96
89.79 1211.08
88.07 1210.15
86.38 1209.16
84.72 1208.12
83.1 1207.03
81.52 1205.89
79.97 1204.69
78.46 1203.45
76.99 1202.16
75.56 1200.82
74.18 1199.44
72.84 1198.01
71.55 1196.54
70.31 1195.03
69.11 1193.48
67.97 1191.9
66.88 1190.28
65.84 1188.62
64.85 1186.93
63.92 1185.21
63.04 1183.47
62.22 1181.69
61.46 1179.89
60.75 1178.07
60.11 1176.22
59.52 1174.35
59 1172.47
58.53 1170.57
58.13 1168.66
57.78 1166.74
57.5 1164.8
57.28 1162.86
57.13 1160.91
57.03 1158.95
57 1157
57.03 1155.04
57.13 1153.09
57.28 1151.14
57.5 1149.2
57.78 1147.26
58.13 1145.34
58.53 1143.43
59 1141.53
59.52 1139.64
60.11 1137.78
60.75 1135.93
61.46 1134.11
62.22 1132.31
63.04 1130.53
63.92 1128.78
64.85 1127.06
65.84 1125.38
66.88 1123.72
67.97 1122.1
69.11 1120.51
70.31 1118.97
71.55 1117.46
72.84 1115.99
74.18 1114.56
75.56 1113.18
76.99 1111.84
78.46 1110.55
79.97 1109.31
81.52 1108.11
83.1 1106.97
84.72 1105.88
86.38 1104.83
88.07 1103.85
89.79 1102.92
91.53 1102.04
93.31 1101.22
95.11 1100.46
96.93 1099.75
98.78 1099.11
100.65 1098.52
102.53 1097.99
104.43 1097.53
106.34 1097.12
108.26 1096.78
110.2 1096.5
112.14 1096.28
114.09 1096.12
116.05 1096.03
118 1096
418 1096
419.25 1095.98
420.5 1095.92
421.74 1095.82
422.99 1095.68
424.22 1095.5
425.45 1095.28
426.68 1095.02
427.89 1094.72
429.1 1094.39
430.29 1094.01
431.47 1093.6
432.64 1093.15
433.79 1092.66
434.92 1092.14
436.04 1091.58
437.14 1090.98
438.22 1090.35
439.28 1089.68
440.31 1088.99
441.33 1088.25
442.32 1087.49
443.28 1086.7
444.22 1085.87
445.13 1085.01
446.02 1084.13
446.87 1083.22
447.7 1082.28
448.49 1081.32
449.26 1080.33
449.99 1079.31
450.69 1078.28
451.35 1077.22
451.98 1076.14
452.58 1075.04
453.14 1073.92
453.66 1072.79
454.15 1071.63
454.6 1070.47
455.01 1069.29
455.39 1068.1
455.72 1066.89
456.02 1065.68
456.28 1064.45
456.5 1063.22
456.68 1061.99
456.82 1060.74
456.92 1059.5
456.98 1058.25
457 1057
456.98 1055.75
456.92 1054.5
456.82 1053.25
456.68 1052.01
456.5 1050.78
456.28 1049.54
456.02 1048.32
455.72 1047.11
455.39 1045.9
455.01 1044.71
454.6 1043.53
454.15 1042.36
453.66 1041.21
453.14 1040.08
452.58 1038.96
451.98 1037.86
451.35 1036.78
450.69 1035.72
449.99 1034.69
449.26 1033.67
448.49 1032.68
447.7 1031.72
446.87 1030.78
446.02 1029.87
445.13 1028.98
444.22 1028.13
443.28 1027.3
442.32 1026.51
441.33 1025.74
440.31 1025.01
439.28 1024.31
438.22 1023.65
437.14 1023.02
436.04 1022.42
434.92 1021.86
433.79 1021.34
432.64 1020.85
431.47 1020.4
430.29 1019.99
429.1 1019.61
427.89 1019.27
426.68 1018.98
425.45 1018.72
424.22 1018.5
422.99 1018.32
421.74 1018.18
420.5 1018.08
419.25 1018.02
418 1018
118 1018
116.05 1017.97
114.09 1017.87
112.14 1017.72
110.2 1017.5
108.26 1017.22
106.34 1016.87
104.43 1016.47
102.53 1016
100.65 1015.48
98.78 1014.89
96.93 1014.25
95.11 1013.54
93.31 1012.78
91.53 1011.96
89.79 1011.08
88.07 1010.15
86.38 1009.16
84.72 1008.12
83.1 1007.03
81.52 1005.88
79.97 1004.69
78.46 1003.45
76.99 1002.16
75.56 1000.82
74.18 999.44
72.84 998.01
71.55 996.54
70.31 995.03
69.11 993.48
67.97 991.9
66.88 990.28
65.84 988.62
64.85 986.93
63.92 985.21
63.04 983.47
62.22 981.69
61.46 979.89
60.75 978.07
60.11 976.22
59.52 974.35
59 972.47
58.53 970.57
58.13 968.66
57.78 966.74
57.5 964.8
57.28 962.86
57.13 960.91
57.03 958.95
57 957
57.03 955.04
57.13 953.09
57.28 951.14
57.5 949.2
57.78 947.26
58.13 945.34
58.53 943.43
59 941.53
59.52 939.64
60.11 937.78
60.75 935.93
61.46 934.11
62.22 932.31
63.04 930.53
63.92 928.78
64.85 927.07
65.84 925.38
66.88 923.72
67.97 922.1
69.11 920.51
70.31 918.97
71.55 917.46
72.84 915.99
74.18 914.56
75.56 913.18
76.99 911.84
78.46 910.55
79.97 909.31
81.52 908.11
83.1 906.97
84.72 905.88
86.38 904.83
88.07 903.85
89.79 902.92
91.53 902.04
93.31 901.22
95.11 900.46
96.93 899.75
98.78 899.11
100.65 898.52
102.53 897.99
104.43 897.53
106.34 897.12
108.26 896.78
110.2 896.5
112.14 896.28
114.09 896.12
116.05 896.03
118 896
418 896
419.25 895.98
420.5 895.92
421.74 895.82
422.99 895.68
424.22 895.5
425.45 895.28
426.68 895.02
427.89 894.72
429.1 894.39
430.29 894.01
431.47 893.6
432.64 893.15
433.79 892.66
434.92 892.14
436.04 891.58
437.14 890.98
438.22 890.35
439.28 889.68
440.31 888.99
441.33 888.25
442.32 887.49
443.28 886.7
444.22 885.87
445.13 885.01
446.02 884.13
446.87 883.22
447.7 882.28
448.49 881.32
449.26 880.32
449.99 879.31
450.69 878.28
451.35 877.22
451.98 876.14
452.58 875.04
453.14 873.92
453.66 872.79
454.15 871.63
454.6 870.47
455.01 869.29
455.39 868.1
455.72 866.89
456.02 865.68
456.28 864.45
456.5 863.22
456.68 861.99
456.82 860.74
456.92 859.5
456.98 858.25
457 857
456.98 855.75
456.92 854.5
456.82 853.25
456.68 852.01
456.5 850.77
456.28 849.54
456.02 848.32
455.72 847.11
455.39 845.9
455.01 844.71
454.6 843.53
454.15 842.36
453.66 841.21
453.14 840.08
452.58 838.96
451.98 837.86
451.35 836.78
450.69 835.72
449.99 834.69
449.26 833.67
448.49 832.68
447.7 831.72
446.87 830.78
446.02 829.87
445.13 828.98
444.22 828.13
443.28 827.3
442.32 826.51
441.33 825.74
440.31 825.01
439.28 824.31
438.22 823.65
437.14 823.02
436.04 822.42
434.92 821.86
433.79 821.34
432.64 820.85
431.47 820.4
430.29 819.99
429.1 819.61
427.89 819.28
426.68 818.98
425.45 818.72
424.22 818.5
422.99 818.32
421.74 818.18
420.5 818.08
419.25 818.02
418 818
118 818
116.05 817.97
114.09 817.87
112.14 817.72
110.2 817.5
108.26 817.22
106.34 816.87
104.43 816.47
102.53 816
100.65 815.48
98.78 814.89
96.93 814.25
95.11 813.54
93.31 812.78
91.53 811.96
89.79 811.08
88.07 810.15
86.38 809.16
84.72 808.12
83.1 807.03
81.52 805.89
79.97 804.69
78.46 803.45
76.99 802.16
75.56 800.82
74.18 799.44
72.84 798.01
71.55 796.54
70.31 795.03
69.11 793.48
67.97 791.9
66.88 790.28
65.84 788.62
64.85 786.93
63.92 785.21
63.04 783.47
62.22 781.69
61.46 779.89
60.75 778.07
60.11 776.22
59.52 774.35
59 772.47
58.53 770.57
58.13 768.66
57.78 766.73
57.5 764.8
57.28 762.86
57.13 760.91
57.03 758.95
57 757
57.03 755.04
57.13 753.09
57.28 751.14
57.5 749.2
57.78 747.26
58.13 745.34
58.53 743.43
59 741.53
59.52 739.64
60.11 737.78
60.75 735.93
61.46 734.11
62.22 732.31
63.04 730.53
63.92 728.78
64.85 727.07
65.84 725.38
66.88 723.72
67.97 722.1
69.12 720.51
70.31 718.97
71.55 717.46
72.84 715.99
74.18 714.56
75.56 713.18
76.99 711.84
78.46 710.55
79.97 709.31
81.52 708.11
83.1 706.97
84.72 705.88
86.38 704.84
88.07 703.85
89.79 702.92
91.53 702.04
93.31 701.22
95.11 700.46
96.93 699.75
98.78 699.11
100.65 698.52
102.53 697.99
104.43 697.53
106.34 697.12
108.26 696.78
110.2 696.5
112.14 696.28
114.09 696.12
116.05 696.03
118 696
418 696
418.63 695.99
419.25 695.98
419.88 695.95
420.5 695.92
421.12 695.87
421.74 695.82
422.37 695.75
422.99 695.68
423.61 695.59
424.22 695.5
424.84 695.39
425.45 695.28
426.07 695.15
426.68 695.02
427.29 694.88
427.89 694.72
428.5 694.56
429.1 694.39
429.69 694.2
430.29 694.01
430.88 693.81
431.47 693.6
432.05 693.38
432.64 693.15
433.21 692.91
433.79 692.66
434.36 692.4
434.92 692.14
435.48 691.86
436.04 691.58
436.59 691.28
437.14 690.98
437.68 690.67
438.22 690.35
438.75 690.02
439.28 689.68
439.8 689.34
440.31 688.99
440.82 688.62
441.33 688.25
441.82 687.88
442.32 687.49
442.8 687.1
443.28 686.7
443.75 686.29
444.22 685.87
444.68 685.45
445.13 685.01
445.58 684.58
446.02 684.13
446.45 683.68
446.87 683.22
447.29 682.75
447.7 682.28
448.1 681.8
448.49 681.32
448.88 680.82
449.26 680.32
449.63 679.82
449.99 679.31
450.34 678.8
450.69 678.28
451.02 677.75
451.35 677.22
451.67 676.68
451.98 676.14
452.28 675.59
452.58 675.04
452.86 674.48
453.14 673.92
453.4 673.35
453.66 672.79
453.91 672.21
454.15 671.63
454.38 671.05
454.6 670.47
454.81 669.88
455.01 669.29
455.2 668.69
455.39 668.1
455.56 667.5
455.72 666.89
455.88 666.29
456.02 665.68
456.16 665.07
456.28 664.45
456.4 663.84
456.5 663.22
456.6 662.61
456.68 661.99
456.76 661.37
456.82 660.74
456.88 660.12
456.92 659.5
456.95 658.87
456.98 658.25
456.99 657.62
457 657
457 653
1 653
1 757
1 957
1 1157
1 1272
157 1272
157 1270.78
END
0 109 -1 N 1972 1 1 100 100 0 0 0 Y
126 1747
210 1747
210 1913
212 1913
212 1745
124 1745
124 1913
80 1913
80 1701
157 1701
157 1697.81
157 1693.22
157 1688.63
157 1684.04
157 1679.45
157 1674.86
157 1670.26
157 1665.67
157 1661.08
157 1656.49
157 1651.9
157 1647.31
157 1642.71
157 1638.12
157 1633.53
157 1628.94
157 1624.35
157 1619.75
157 1615.16
157 1610.57
157 1605.98
157 1601.39
157 1596.8
157 1592.2
157 1587.61
157 1583.02
157 1578.43
157 1573.84
157 1569.24
157 1564.65
157 1560.06
157 1555.47
157 1550.88
157 1546.28
157 1541.69
157 1537.1
157 1532.51
157 1527.92
157 1523.33
157 1518.73
157 1514.14
157 1509.55
157 1504.96
157 1500.37
157 1495.78
157 1491.18
157 1486.59
157 1482
157 1477.41
157 1472.82
157 1468.22
157 1463.63
157 1459.04
157 1454.45
157 1449.86
157 1445.26
157 1440.67
157 1436.08
157 1431.49
157 1426.9
157 1422.31
157 1417.71
157 1413.12
157 1408.53
157 1403.94
157 1399.35
157 1394.75
157 1390.16
157 1385.57
157 1380.98
157 1376.39
157 1371.8
157 1367.2
157 1362.61
157 1358.02
157 1353.43
157 1348.84
157 1344.24
157 1339.65
157 1335.06
157 1330.47
157 1325.88
157 1321.28
157 1316.69
157 1312.1
157 1307.51
157 1302.92
157 1298.33
157 1293.73
157 1289.14
157 1284.55
157 1279.96
157 1275.37
157 1272
1 1272
2.194070915e-005 1913
2.194070915e-005 2111.999971
126 2111.999971
126 1747
END
0 1395 -1 V 1973 1 1 100 100 0 0 0 Y
173 1270.77
173 1266.18
173 1261.59
173 1257
172.99 1256.12
172.97 1255.24
172.94 1254.36
172.89 1253.47
172.82 1252.6
172.75 1251.72
172.66 1250.84
172.55 1249.97
172.43 1249.09
172.3 1248.22
172.15 1247.35
171.99 1246.48
171.81 1245.62
171.62 1244.76
171.42 1243.9
171.2 1243.05
170.97 1242.2
170.73 1241.35
170.47 1240.51
170.2 1239.67
169.92 1238.83
169.62 1238
169.31 1237.18
168.98 1236.36
168.64 1235.55
168.29 1234.74
167.93 1233.93
167.55 1233.13
167.17 1232.34
166.76 1231.56
166.35 1230.78
165.92 1230.01
165.49 1229.24
165.03 1228.49
164.57 1227.74
164.1 1226.99
163.61 1226.26
163.11 1225.53
162.6 1224.81
162.08 1224.1
161.55 1223.4
161 1222.71
160.45 1222.02
159.88 1221.35
159.3 1220.68
158.72 1220.02
158.12 1219.37
157.51 1218.74
156.89 1218.11
156.26 1217.49
155.63 1216.88
154.98 1216.28
154.32 1215.7
153.65 1215.12
152.98 1214.55
152.29 1214
151.6 1213.45
150.9 1212.92
150.19 1212.4
149.47 1211.89
148.74 1211.39
148.01 1210.9
147.26 1210.43
146.51 1209.97
145.76 1209.52
144.99 1209.08
144.22 1208.65
143.44 1208.24
142.66 1207.83
141.86 1207.45
141.07 1207.07
140.26 1206.71
139.45 1206.36
138.64 1206.02
137.82 1205.69
137 1205.38
136.17 1205.08
135.33 1204.8
134.49 1204.53
133.65 1204.27
132.8 1204.03
131.95 1203.8
131.1 1203.58
130.24 1203.38
129.38 1203.19
128.52 1203.01
127.65 1202.85
126.78 1202.7
125.91 1202.57
125.03 1202.45
124.16 1202.35
123.28 1202.25
122.4 1202.18
121.52 1202.11
120.65 1202.06
119.76 1202.03
118.88 1202.01
118 1202
116.56 1201.98
115.12 1201.91
113.68 1201.79
112.25 1201.63
110.82 1201.42
109.4 1201.17
107.99 1200.87
106.59 1200.53
105.2 1200.14
103.82 1199.71
102.46 1199.23
101.11 1198.71
99.79 1198.15
98.48 1197.54
97.19 1196.9
95.92 1196.21
94.67 1195.48
93.45 1194.71
92.26 1193.91
91.09 1193.06
89.94 1192.18
88.83 1191.26
87.75 1190.31
86.69 1189.33
85.68 1188.31
84.69 1187.25
83.74 1186.17
82.82 1185.06
81.94 1183.91
81.09 1182.74
80.29 1181.55
79.52 1180.33
78.79 1179.08
78.1 1177.81
77.46 1176.52
76.85 1175.21
76.29 1173.89
75.77 1172.54
75.29 1171.18
74.86 1169.8
74.47 1168.41
74.13 1167.01
73.83 1165.6
73.58 1164.18
73.37 1162.75
73.21 1161.32
73.09 1159.88
73.02 1158.44
73 1157
73.02 1155.56
73.09 1154.12
73.21 1152.68
73.37 1151.24
73.58 1149.82
73.83 1148.4
74.13 1146.99
74.47 1145.58
74.86 1144.19
75.29 1142.82
75.77 1141.46
76.29 1140.11
76.85 1138.78
77.46 1137.47
78.1 1136.18
78.79 1134.92
79.52 1133.67
80.29 1132.45
81.09 1131.25
81.94 1130.08
82.82 1128.94
83.74 1127.83
84.69 1126.74
85.68 1125.69
86.69 1124.67
87.75 1123.69
88.83 1122.73
89.94 1121.82
91.09 1120.94
92.26 1120.09
93.45 1119.29
94.67 1118.52
95.92 1117.79
97.19 1117.1
98.48 1116.45
99.79 1115.85
101.11 1115.29
102.46 1114.77
103.82 1114.29
105.2 1113.86
106.59 1113.47
107.99 1113.13
109.4 1112.83
110.82 1112.58
112.25 1112.37
113.68 1112.21
115.12 1112.09
116.56 1112.02
118 1112
418 1112
419.76 1111.97
421.52 1111.89
423.28 1111.74
425.03 1111.55
426.78 1111.29
428.51 1110.99
430.24 1110.62
431.95 1110.2
433.65 1109.73
435.33 1109.2
436.99 1108.61
438.64 1107.98
440.26 1107.29
441.86 1106.55
443.44 1105.76
444.99 1104.92
446.51 1104.03
448 1103.09
449.47 1102.11
450.9 1101.08
452.29 1100
453.65 1098.88
454.98 1097.71
456.26 1096.51
457.51 1095.26
458.72 1093.98
459.88 1092.65
461 1091.29
462.08 1089.89
463.11 1088.47
464.1 1087
465.03 1085.51
465.92 1083.99
466.76 1082.44
467.55 1080.86
468.29 1079.26
468.98 1077.64
469.62 1075.99
470.2 1074.33
470.73 1072.65
471.2 1070.95
471.62 1069.24
471.99 1067.51
472.3 1065.78
472.55 1064.03
472.75 1062.28
472.89 1060.52
472.97 1058.76
473 1057
472.97 1055.24
472.89 1053.47
472.75 1051.72
472.55 1049.97
472.3 1048.22
471.99 1046.48
471.62 1044.76
471.2 1043.05
470.73 1041.35
470.2 1039.67
469.62 1038
468.98 1036.36
468.29 1034.74
467.55 1033.14
466.76 1031.56
465.92 1030.01
465.03 1028.49
464.1 1027
463.11 1025.53
462.08 1024.1
461 1022.71
459.88 1021.35
458.72 1020.02
457.51 1018.74
456.26 1017.49
454.98 1016.28
453.65 1015.12
452.29 1014
450.9 1012.92
449.47 1011.89
448 1010.9
446.51 1009.97
444.99 1009.08
443.44 1008.24
441.86 1007.45
440.26 1006.71
438.64 1006.02
436.99 1005.38
435.33 1004.8
433.65 1004.27
431.95 1003.8
430.24 1003.38
428.51 1003.01
426.78 1002.7
425.03 1002.45
423.28 1002.25
421.52 1002.11
419.76 1002.03
418 1002
118 1002
116.56 1001.98
115.12 1001.91
113.68 1001.79
112.25 1001.63
110.82 1001.42
109.4 1001.17
107.99 1000.87
106.59 1000.53
105.2 1000.14
103.82 999.71
102.46 999.23
101.11 998.71
99.79 998.15
98.48 997.54
97.19 996.9
95.92 996.21
94.67 995.48
93.45 994.71
92.26 993.91
91.09 993.06
89.94 992.18
88.83 991.26
87.75 990.31
86.69 989.32
85.68 988.3
84.69 987.25
83.74 986.17
82.82 985.06
81.94 983.91
81.09 982.74
80.29 981.55
79.52 980.33
78.79 979.08
78.1 977.81
77.46 976.52
76.85 975.21
76.29 973.89
75.77 972.54
75.29 971.18
74.86 969.8
74.47 968.41
74.13 967.01
73.83 965.6
73.58 964.18
73.37 962.75
73.21 961.32
73.09 959.88
73.02 958.44
73 957
73.02 955.56
73.09 954.12
73.21 952.68
73.37 951.24
73.58 949.82
73.83 948.4
74.13 946.99
74.47 945.58
74.86 944.2
75.29 942.82
75.77 941.46
76.29 940.11
76.85 938.78
77.46 937.47
78.1 936.18
78.79 934.92
79.52 933.67
80.29 932.45
81.09 931.25
81.94 930.08
82.82 928.94
83.74 927.83
84.69 926.74
85.68 925.69
86.69 924.67
87.75 923.69
88.83 922.73
89.94 921.82
91.09 920.93
92.26 920.09
93.45 919.28
94.67 918.52
95.92 917.79
97.19 917.1
98.48 916.45
99.79 915.85
101.11 915.29
102.46 914.77
103.82 914.29
105.2 913.86
106.59 913.47
107.99 913.13
109.4 912.83
110.82 912.58
112.25 912.37
113.68 912.21
115.12 912.09
116.56 912.02
118 912
418 912
419.76 911.97
421.52 911.89
423.28 911.75
425.03 911.55
426.78 911.29
428.51 910.99
430.24 910.62
431.95 910.2
433.65 909.73
435.33 909.2
436.99 908.61
438.64 907.98
440.26 907.29
441.86 906.55
443.44 905.76
444.99 904.92
446.51 904.03
448 903.09
449.47 902.11
450.9 901.08
452.29 900
453.65 898.88
454.98 897.71
456.26 896.51
457.51 895.26
458.72 893.98
459.88 892.65
461 891.29
462.08 889.89
463.11 888.47
464.1 887
465.03 885.51
465.92 883.99
466.76 882.44
467.55 880.86
468.29 879.26
468.98 877.64
469.62 875.99
470.2 874.33
470.73 872.65
471.2 870.95
471.62 869.24
471.99 867.51
472.3 865.78
472.55 864.03
472.75 862.28
472.89 860.52
472.97 858.76
473 857
472.97 855.24
472.89 853.47
472.75 851.72
472.55 849.97
472.3 848.22
471.99 846.49
471.62 844.76
471.2 843.05
470.73 841.35
470.2 839.67
469.62 838
468.98 836.36
468.29 834.74
467.55 833.14
466.76 831.56
465.92 830.01
465.03 828.49
464.09 827
463.11 825.53
462.08 824.1
461 822.71
459.88 821.35
458.72 820.02
457.51 818.74
456.26 817.49
454.98 816.28
453.65 815.12
452.29 814
450.9 812.92
449.47 811.89
448 810.9
446.51 809.97
444.99 809.08
443.44 808.24
441.86 807.45
440.26 806.71
438.64 806.02
436.99 805.38
435.33 804.8
433.65 804.27
431.95 803.8
430.24 803.38
428.51 803.01
426.78 802.7
425.03 802.45
423.28 802.25
421.52 802.11
419.76 802.03
418 802
118 802
116.56 801.98
115.12 801.91
113.68 801.79
112.25 801.63
110.82 801.42
109.4 801.17
107.99 800.87
106.59 800.53
105.2 800.14
103.82 799.71
102.46 799.23
101.11 798.71
99.79 798.15
98.48 797.54
97.19 796.9
95.92 796.21
94.67 795.48
93.45 794.71
92.26 793.91
91.09 793.06
89.94 792.18
88.83 791.26
87.75 790.31
86.69 789.32
85.67 788.31
84.69 787.25
83.74 786.17
82.82 785.06
81.94 783.91
81.09 782.74
80.29 781.55
79.52 780.33
78.79 779.08
78.1 777.81
77.46 776.52
76.85 775.21
76.29 773.89
75.77 772.54
75.29 771.18
74.86 769.8
74.47 768.41
74.13 767.01
73.83 765.6
73.58 764.18
73.37 762.75
73.21 761.32
73.09 759.88
73.02 758.44
73 757
73.02 755.56
73.09 754.12
73.21 752.68
73.37 751.24
73.58 749.82
73.83 748.4
74.13 746.99
74.47 745.59
74.86 744.19
75.29 742.82
75.77 741.46
76.29 740.11
76.85 738.78
77.46 737.47
78.1 736.18
78.79 734.92
79.52 733.67
80.29 732.45
81.09 731.25
81.94 730.08
82.82 728.94
83.74 727.83
84.69 726.74
85.67 725.69
86.69 724.67
87.75 723.69
88.83 722.73
89.94 721.82
91.09 720.94
92.26 720.09
93.45 719.28
94.67 718.52
95.92 717.79
97.19 717.1
98.48 716.45
99.79 715.85
101.11 715.29
102.46 714.77
103.82 714.29
105.2 713.86
106.59 713.47
107.99 713.13
109.4 712.83
110.82 712.58
112.25 712.37
113.68 712.21
115.12 712.09
116.56 712.02
118 712
418 712
418.88 711.99
419.76 711.97
420.64 711.93
421.52 711.89
422.4 711.82
423.28 711.74
424.16 711.65
425.03 711.55
425.91 711.43
426.78 711.29
427.65 711.15
428.51 710.99
429.38 710.81
430.24 710.62
431.1 710.42
431.95 710.2
432.8 709.97
433.65 709.73
434.49 709.47
435.33 709.2
436.17 708.91
436.99 708.61
437.82 708.3
438.64 707.98
439.45 707.64
440.26 707.29
441.07 706.93
441.86 706.55
442.65 706.16
443.44 705.76
444.22 705.35
444.99 704.92
445.75 704.48
446.51 704.03
447.26 703.57
448 703.09
448.74 702.61
449.47 702.11
450.19 701.6
450.9 701.08
451.6 700.54
452.29 700
452.98 699.45
453.65 698.88
454.32 698.3
454.98 697.71
455.62 697.12
456.26 696.51
456.89 695.89
457.51 695.26
458.12 694.62
458.72 693.98
459.3 693.32
459.88 692.65
460.45 691.98
461 691.29
461.55 690.6
462.08 689.89
462.6 689.18
463.11 688.46
463.61 687.74
464.1 687
464.57 686.26
465.03 685.51
465.48 684.75
465.92 683.99
466.35 683.22
466.76 682.44
467.16 681.65
467.55 680.86
467.93 680.07
468.29 679.26
468.64 678.45
468.98 677.64
469.31 676.82
469.62 675.99
469.91 675.16
470.2 674.33
470.47 673.49
470.73 672.65
470.97 671.8
471.2 670.95
471.42 670.1
471.62 669.24
471.81 668.38
471.99 667.51
472.15 666.65
472.3 665.78
472.43 664.91
472.55 664.03
472.65 663.16
472.75 662.28
472.82 661.4
472.89 660.52
472.94 659.64
472.97 658.76
472.99 657.88
473 657
473 653
463 653
463 657
462.99 657.72
462.98 658.44
462.95 659.16
462.91 659.88
462.86 660.6
462.79 661.32
462.72 662.04
462.63 662.75
462.53 663.47
462.42 664.18
462.3 664.89
462.17 665.6
462.03 666.31
461.87 667.01
461.71 667.71
461.53 668.41
461.34 669.11
461.14 669.8
460.93 670.49
460.71 671.18
460.48 671.86
460.23 672.54
459.98 673.22
459.71 673.89
459.43 674.55
459.15 675.21
458.85 675.87
458.54 676.52
458.23 677.17
457.9 677.81
457.56 678.45
457.21 679.08
456.85 679.71
456.48 680.33
456.1 680.94
455.71 681.55
455.32 682.15
454.91 682.74
454.49 683.33
454.06 683.91
453.63 684.49
453.18 685.06
452.73 685.62
452.27 686.17
451.79 686.72
451.31 687.25
450.82 687.78
450.33 688.31
449.82 688.82
449.31 689.32
448.78 689.82
448.25 690.31
447.72 690.79
447.17 691.26
446.62 691.73
446.06 692.18
445.49 692.63
444.92 693.06
444.33 693.49
443.75 693.91
443.15 694.32
442.55 694.71
441.94 695.1
441.33 695.48
440.71 695.85
440.08 696.21
439.45 696.56
438.81 696.9
438.17 697.22
437.52 697.54
436.87 697.85
436.22 698.15
435.55 698.43
434.89 698.71
434.22 698.98
433.54 699.23
432.86 699.47
432.18 699.71
431.49 699.93
430.8 700.14
430.11 700.34
429.41 700.53
428.71 700.71
428.01 700.87
427.31 701.03
426.6 701.17
425.89 701.3
425.18 701.42
424.47 701.53
423.75 701.63
423.04 701.72
422.32 701.79
421.6 701.85
420.88 701.91
420.16 701.95
419.44 701.98
418.72 701.99
418 702
118 702
116.24 702.03
114.48 702.11
112.72 702.25
110.97 702.45
109.22 702.7
107.49 703.01
105.76 703.38
104.05 703.8
102.35 704.27
100.67 704.8
99.01 705.38
97.36 706.02
95.74 706.71
94.14 707.45
92.56 708.24
91.01 709.08
89.49 709.97
88 710.9
86.53 711.89
85.1 712.92
83.71 714
82.35 715.12
81.02 716.28
79.74 717.49
78.49 718.74
77.29 720.02
76.12 721.35
75 722.71
73.92 724.1
72.89 725.53
71.91 726.99
70.97 728.49
70.08 730.01
69.24 731.56
68.45 733.13
67.71 734.74
67.02 736.36
66.39 738
65.8 739.67
65.27 741.35
64.8 743.05
64.38 744.76
64.02 746.49
63.71 748.22
63.45 749.97
63.26 751.72
63.11 753.48
63.03 755.24
63 757
63.03 758.76
63.11 760.52
63.26 762.28
63.45 764.03
63.71 765.78
64.01 767.51
64.38 769.24
64.8 770.95
65.27 772.65
65.8 774.33
66.39 775.99
67.02 777.64
67.71 779.26
68.45 780.86
69.24 782.44
70.08 783.99
70.97 785.51
71.91 787
72.89 788.47
73.92 789.89
75 791.29
76.12 792.65
77.29 793.98
78.49 795.26
79.74 796.51
81.02 797.71
82.35 798.88
83.71 800
85.1 801.08
86.53 802.11
88 803.09
89.49 804.03
91.01 804.92
92.56 805.76
94.14 806.55
95.74 807.29
97.36 807.98
99.01 808.62
100.67 809.2
102.35 809.73
104.05 810.2
105.76 810.62
107.49 810.98
109.22 811.29
110.97 811.55
112.72 811.74
114.48 811.89
116.24 811.97
118 812
418 812
419.44 812.02
420.88 812.09
422.32 812.21
423.75 812.37
425.18 812.58
426.6 812.83
428.01 813.13
429.41 813.47
430.8 813.86
432.18 814.29
433.54 814.77
434.89 815.29
436.21 815.85
437.53 816.45
438.81 817.1
440.08 817.79
441.33 818.52
442.55 819.28
443.74 820.09
444.92 820.94
446.06 821.82
447.17 822.73
448.25 823.69
449.31 824.67
450.33 825.69
451.31 826.74
452.27 827.83
453.18 828.94
454.06 830.08
454.91 831.25
455.71 832.45
456.48 833.67
457.21 834.92
457.9 836.19
458.54 837.47
459.15 838.78
459.71 840.11
460.23 841.46
460.71 842.82
461.14 844.2
461.53 845.58
461.87 846.99
462.17 848.4
462.42 849.82
462.63 851.24
462.79 852.68
462.91 854.12
462.98 855.56
463 857
462.98 858.44
462.91 859.88
462.79 861.32
462.63 862.75
462.42 864.18
462.17 865.6
461.87 867.01
461.53 868.41
461.14 869.8
460.71 871.18
460.23 872.54
459.71 873.89
459.15 875.21
458.54 876.52
457.9 877.81
457.21 879.08
456.48 880.33
455.71 881.55
454.91 882.74
454.06 883.91
453.18 885.06
452.27 886.17
451.31 887.25
450.33 888.3
449.31 889.33
448.25 890.31
447.17 891.26
446.06 892.18
444.92 893.06
443.74 893.91
442.55 894.71
441.33 895.48
440.08 896.21
438.81 896.9
437.52 897.54
436.22 898.15
434.89 898.71
433.54 899.23
432.18 899.71
430.8 900.14
429.41 900.53
428.01 900.87
426.6 901.17
425.18 901.42
423.75 901.63
422.32 901.79
420.88 901.91
419.44 901.98
418 902
118 902
116.24 902.03
114.48 902.11
112.72 902.25
110.97 902.45
109.22 902.7
107.49 903.01
105.76 903.38
104.05 903.8
102.35 904.27
100.67 904.8
99.01 905.38
97.36 906.02
95.74 906.71
94.14 907.45
92.56 908.24
91.01 909.08
89.49 909.97
88 910.9
86.53 911.89
85.1 912.92
83.71 914
82.35 915.12
81.02 916.28
79.74 917.49
78.49 918.74
77.29 920.02
76.12 921.35
75 922.71
73.92 924.1
72.89 925.53
71.91 926.99
70.97 928.49
70.08 930.01
69.24 931.56
68.45 933.14
67.71 934.74
67.02 936.36
66.39 938
65.8 939.67
65.27 941.35
64.8 943.05
64.38 944.76
64.02 946.48
63.71 948.22
63.45 949.97
63.26 951.72
63.11 953.47
63.03 955.24
63 957
63.03 958.76
63.11 960.52
63.26 962.28
63.45 964.03
63.71 965.78
64.01 967.51
64.38 969.24
64.8 970.95
65.27 972.65
65.8 974.33
66.39 975.99
67.02 977.64
67.71 979.26
68.45 980.86
69.24 982.44
70.08 983.99
70.97 985.51
71.91 987
72.89 988.47
73.92 989.89
75 991.29
76.12 992.65
77.29 993.98
78.49 995.26
79.74 996.51
81.02 997.71
82.35 998.88
83.71 1000
85.1 1001.08
86.53 1002.11
88 1003.09
89.49 1004.03
91.01 1004.92
92.56 1005.76
94.14 1006.55
95.74 1007.29
97.36 1007.98
99.01 1008.61
100.67 1009.2
102.35 1009.73
104.05 1010.2
105.76 1010.62
107.49 1010.99
109.22 1011.29
110.97 1011.55
112.72 1011.74
114.48 1011.89
116.24 1011.97
118 1012
418 1012
419.44 1012.02
420.88 1012.09
422.32 1012.21
423.75 1012.37
425.18 1012.58
426.6 1012.83
428.01 1013.13
429.41 1013.47
430.8 1013.86
432.18 1014.29
433.54 1014.77
434.89 1015.29
436.22 1015.85
437.52 1016.45
438.81 1017.1
440.08 1017.79
441.33 1018.52
442.55 1019.28
443.74 1020.09
444.92 1020.93
446.06 1021.82
447.17 1022.73
448.25 1023.69
449.31 1024.67
450.33 1025.69
451.31 1026.75
452.27 1027.83
453.18 1028.94
454.06 1030.08
454.91 1031.25
455.71 1032.45
456.48 1033.67
457.21 1034.92
457.9 1036.19
458.54 1037.47
459.15 1038.78
459.71 1040.11
460.23 1041.46
460.71 1042.82
461.14 1044.2
461.53 1045.58
461.87 1046.99
462.17 1048.4
462.42 1049.82
462.63 1051.24
462.79 1052.68
462.91 1054.12
462.98 1055.56
463 1057
462.98 1058.44
462.91 1059.88
462.79 1061.32
462.63 1062.75
462.42 1064.18
462.17 1065.6
461.87 1067.01
461.53 1068.41
461.14 1069.8
460.71 1071.18
460.23 1072.54
459.71 1073.89
459.15 1075.21
458.54 1076.52
457.9 1077.81
457.21 1079.08
456.48 1080.33
455.71 1081.55
454.91 1082.74
454.06 1083.91
453.18 1085.06
452.26 1086.17
451.31 1087.25
450.33 1088.3
449.31 1089.33
448.25 1090.31
447.17 1091.26
446.06 1092.18
444.92 1093.06
443.75 1093.91
442.55 1094.71
441.33 1095.48
440.08 1096.21
438.81 1096.9
437.52 1097.54
436.22 1098.15
434.89 1098.71
433.54 1099.23
432.18 1099.71
430.8 1100.14
429.41 1100.53
428.01 1100.87
426.6 1101.17
425.18 1101.42
423.75 1101.63
422.32 1101.79
420.88 1101.91
419.44 1101.98
418 1102
118 1102
116.24 1102.03
114.48 1102.11
112.72 1102.25
110.97 1102.45
109.22 1102.7
107.49 1103.01
105.76 1103.38
104.05 1103.8
102.35 1104.27
100.67 1104.8
99.01 1105.38
97.36 1106.02
95.74 1106.71
94.14 1107.45
92.56 1108.24
91.01 1109.08
89.49 1109.97
88 1110.9
86.53 1111.89
85.1 1112.92
83.71 1114
82.35 1115.12
81.02 1116.28
79.74 1117.49
78.49 1118.74
77.29 1120.02
76.12 1121.35
75 1122.71
73.92 1124.1
72.89 1125.53
71.91 1126.99
70.97 1128.49
70.08 1130.01
69.24 1131.56
68.45 1133.14
67.71 1134.74
67.02 1136.36
66.39 1138
65.8 1139.67
65.27 1141.35
64.8 1143.05
64.38 1144.76
64.02 1146.49
63.71 1148.22
63.45 1149.97
63.26 1151.72
63.11 1153.48
63.03 1155.24
63 1157
63.03 1158.76
63.11 1160.52
63.26 1162.28
63.45 1164.03
63.71 1165.78
64.02 1167.51
64.38 1169.24
64.8 1170.95
65.27 1172.65
65.8 1174.33
66.39 1175.99
67.02 1177.64
67.71 1179.26
68.45 1180.86
69.24 1182.44
70.08 1183.99
70.97 1185.51
71.91 1187
72.89 1188.47
73.92 1189.9
75 1191.29
76.12 1192.65
77.29 1193.98
78.49 1195.26
79.74 1196.51
81.02 1197.71
82.35 1198.88
83.71 1200
85.1 1201.08
86.53 1202.11
88 1203.09
89.49 1204.03
91.01 1204.92
92.56 1205.76
94.14 1206.55
95.74 1207.29
97.36 1207.98
99.01 1208.62
100.67 1209.2
102.35 1209.73
104.05 1210.2
105.76 1210.62
107.49 1210.99
109.22 1211.29
110.97 1211.55
112.72 1211.75
114.48 1211.89
116.24 1211.97
118 1212
118.72 1212.01
119.44 1212.02
120.16 1212.05
120.88 1212.09
121.6 1212.14
122.32 1212.21
123.04 1212.28
123.76 1212.37
124.47 1212.47
125.18 1212.58
125.89 1212.7
126.6 1212.83
127.31 1212.97
128.01 1213.13
128.72 1213.29
129.42 1213.47
130.11 1213.66
130.81 1213.86
131.49 1214.07
132.18 1214.29
132.86 1214.52
133.54 1214.77
134.22 1215.02
134.89 1215.29
135.55 1215.56
136.22 1215.85
136.87 1216.15
137.53 1216.45
138.17 1216.77
138.82 1217.1
139.45 1217.44
140.08 1217.79
140.71 1218.15
141.33 1218.52
141.94 1218.9
142.55 1219.29
143.15 1219.68
143.75 1220.09
144.33 1220.51
144.92 1220.93
145.49 1221.37
146.06 1221.82
146.62 1222.27
147.17 1222.73
147.72 1223.21
148.26 1223.69
148.78 1224.18
149.31 1224.67
149.82 1225.18
150.33 1225.69
150.82 1226.22
151.31 1226.74
151.79 1227.28
152.27 1227.83
152.73 1228.38
153.18 1228.94
153.63 1229.51
154.06 1230.08
154.49 1230.67
154.91 1231.25
155.32 1231.85
155.72 1232.45
156.1 1233.06
156.48 1233.67
156.85 1234.29
157.21 1234.92
157.56 1235.55
157.9 1236.18
158.23 1236.83
158.55 1237.47
158.85 1238.13
159.15 1238.78
159.44 1239.45
159.71 1240.11
159.98 1240.78
160.23 1241.46
160.48 1242.14
160.71 1242.82
160.93 1243.5
161.14 1244.19
161.34 1244.89
161.53 1245.58
161.71 1246.28
161.87 1246.99
162.03 1247.69
162.17 1248.4
162.3 1249.11
162.42 1249.82
162.53 1250.53
162.63 1251.25
162.72 1251.96
162.79 1252.68
162.86 1253.4
162.91 1254.12
162.95 1254.84
162.98 1255.56
163 1256.28
163 1257
163 1261.59
163 1266.18
163 1270.78
163 1272
173 1272
173 1270.77
END
0 201 -1 N 1974 1 1 100 100 0 0 0 Y
250 1707
173 1707
173 1702.41
173 1697.81
173 1693.22
173 1688.63
173 1684.04
173 1679.45
173 1674.86
173 1670.26
173 1665.67
173 1661.08
173 1656.49
173 1651.9
173 1647.31
173 1642.71
173 1638.12
173 1633.53
173 1628.94
173 1624.35
173 1619.75
173 1615.16
173 1610.57
173 1605.98
173 1601.39
173 1596.8
173 1592.2
173 1587.61
173 1583.02
173 1578.43
173 1573.84
173 1569.24
173 1564.65
173 1560.06
173 1555.47
173 1550.88
173 1546.28
173 1541.69
173 1537.1
173 1532.51
173 1527.92
173 1523.33
173 1518.73
173 1514.14
173 1509.55
173 1504.96
173 1500.37
173 1495.77
173 1491.18
173 1486.59
173 1482
173 1477.41
173 1472.82
173 1468.22
173 1463.63
173 1459.04
173 1454.45
173 1449.86
173 1445.26
173 1440.67
173 1436.08
173 1431.49
173 1426.9
173 1422.31
173 1417.71
173 1413.12
173 1408.53
173 1403.94
173 1399.35
173 1394.75
173 1390.16
173 1385.57
173 1380.98
173 1376.39
173 1371.79
173 1367.2
173 1362.61
173 1358.02
173 1353.43
173 1348.84
173 1344.24
173 1339.65
173 1335.06
173 1330.47
173 1325.88
173 1321.28
173 1316.69
173 1312.1
173 1307.51
173 1302.92
173 1298.33
173 1293.73
173 1289.14
173 1284.55
173 1279.96
173 1275.37
173 1272
163 1272
163 1275.37
163 1279.96
163 1284.55
163 1289.14
163 1293.73
163 1298.33
163 1302.92
163 1307.51
163 1312.1
163 1316.69
163 1321.29
163 1325.88
163 1330.47
163 1335.06
163 1339.65
163 1344.24
163 1348.84
163 1353.43
163 1358.02
163 1362.61
163 1367.2
163 1371.8
163 1376.39
163 1380.98
163 1385.57
163 1390.16
163 1394.75
163 1399.35
163 1403.94
163 1408.53
163 1413.12
163 1417.71
163 1422.31
163 1426.9
163 1431.49
163 1436.08
163 1440.67
163 1445.26
163 1449.86
163 1454.45
163 1459.04
163 1463.63
163 1468.22
163 1472.82
163 1477.41
163 1482
163 1486.59
163 1491.18
163 1495.78
163 1500.37
163 1504.96
163 1509.55
163 1514.14
163 1518.73
163 1523.33
163 1527.92
163 1532.51
163 1537.1
163 1541.69
163 1546.29
163 1550.88
163 1555.47
163 1560.06
163 1564.65
163 1569.24
163 1573.84
163 1578.43
163 1583.02
163 1587.61
163 1592.2
163 1596.8
163 1601.39
163 1605.98
163 1610.57
163 1615.16
163 1619.75
163 1624.35
163 1628.94
163 1633.53
163 1638.12
163 1642.71
163 1647.31
163 1651.9
163 1656.49
163 1661.08
163 1665.67
163 1670.26
163 1674.86
163 1679.45
163 1684.04
163 1688.63
163 1693.22
163 1697.82
163 1702.41
163 1707
86 1707
86 1907
118 1907
118 1739
218 1739
218 1907
250 1907
250 1707
END
0 102 -1 N 1975 1 1 100 100 0 0 0 Y
546 1272
179 1272
179 1275.37
179 1279.96
179 1284.55
179 1289.14
179 1293.73
179 1298.33
179 1302.92
179 1307.51
179 1312.1
179 1316.69
179 1321.29
179 1325.88
179 1330.47
179 1335.06
179 1339.65
179 1344.24
179 1348.84
179 1353.43
179 1358.02
179 1362.61
179 1367.2
179 1371.8
179 1376.39
179 1380.98
179 1385.57
179 1390.16
179 1394.75
179 1399.35
179 1403.94
179 1408.53
179 1413.12
179 1417.71
179 1422.31
179 1426.9
179 1431.49
179 1436.08
179 1440.67
179 1445.26
179 1449.86
179 1454.45
179 1459.04
179 1463.63
179 1468.22
179 1472.82
179 1477.41
179 1482
179 1486.59
179 1491.18
179 1495.78
179 1500.37
179 1504.96
179 1509.55
179 1514.14
179 1518.73
179 1523.33
179 1527.92
179 1532.51
179 1537.1
179 1541.69
179 1546.28
179 1550.88
179 1555.47
179 1560.06
179 1564.65
179 1569.24
179 1573.84
179 1578.43
179 1583.02
179 1587.61
179 1592.2
179 1596.8
179 1601.39
179 1605.98
179 1610.57
179 1615.16
179 1619.75
179 1624.35
179 1628.94
179 1633.53
179 1638.12
179 1642.71
179 1647.31
179 1651.9
179 1656.49
179 1661.08
179 1665.67
179 1670.26
179 1674.86
179 1679.45
179 1684.04
179 1688.63
179 1693.22
179 1697.81
179 1701
256 1701
256 1913
209.9999999 1913
209.9999999 2111.999971
546 2111.999971
546 1272
END
0 701 -1 T 1976 1 1 100 100 0 0 0 Y
546 657
546 653
479 653
479 657
478.99 657.98
478.97 658.95
478.93 659.93
478.87 660.91
478.8 661.88
478.72 662.86
478.62 663.83
478.5 664.8
478.37 665.77
478.22 666.74
478.05 667.7
477.88 668.66
477.68 669.62
477.47 670.57
477.24 671.52
477.01 672.47
476.75 673.42
476.48 674.35
476.19 675.29
475.89 676.22
475.58 677.15
475.25 678.07
474.9 678.98
474.54 679.89
474.17 680.79
473.78 681.69
473.38 682.58
472.96 683.47
472.53 684.34
472.08 685.21
471.62 686.08
471.15 686.93
470.66 687.78
470.16 688.62
469.65 689.45
469.12 690.28
468.58 691.09
468.03 691.9
467.46 692.7
466.89 693.48
466.29 694.26
465.69 695.03
465.08 695.79
464.45 696.54
463.81 697.28
463.16 698.01
462.49 698.73
461.82 699.44
461.13 700.13
460.44 700.82
459.73 701.49
459.01 702.16
458.28 702.81
457.54 703.45
456.79 704.08
456.03 704.69
455.26 705.29
454.48 705.89
453.7 706.46
452.9 707.03
452.09 707.58
451.28 708.12
450.45 708.65
449.62 709.16
448.78 709.66
447.93 710.15
447.08 710.62
446.22 711.08
445.34 711.53
444.47 711.96
443.58 712.37
442.69 712.78
441.8 713.17
440.89 713.54
439.98 713.9
439.07 714.25
438.15 714.58
437.22 714.89
436.29 715.19
435.36 715.48
434.42 715.75
433.47 716
432.52 716.24
431.57 716.47
430.62 716.68
429.66 716.87
428.7 717.05
427.74 717.22
426.77 717.36
425.8 717.5
424.83 717.61
423.86 717.72
422.88 717.8
421.91 717.87
420.93 717.93
419.95 717.97
418.98 717.99
418 718
118 718
116.75 718.02
115.5 718.08
114.26 718.18
113.01 718.32
111.78 718.5
110.55 718.72
109.32 718.98
108.11 719.28
106.9 719.61
105.71 719.99
104.53 720.4
103.37 720.85
102.21 721.34
101.08 721.86
99.96 722.42
98.86 723.02
97.78 723.65
96.73 724.31
95.69 725.01
94.68 725.74
93.69 726.51
92.72 727.3
91.78 728.13
90.87 728.98
89.99 729.87
89.13 730.78
88.3 731.72
87.51 732.68
86.75 733.67
86.01 734.69
85.32 735.72
84.65 736.78
84.02 737.86
83.42 738.96
82.86 740.08
82.34 741.21
81.85 742.36
81.4 743.53
80.99 744.71
80.61 745.9
80.28 747.11
79.98 748.32
79.72 749.54
79.5 750.77
79.32 752.01
79.18 753.25
79.08 754.5
79.02 755.75
79 757
79.02 758.25
79.08 759.5
79.18 760.74
79.32 761.99
79.5 763.22
79.72 764.45
79.98 765.68
80.28 766.89
80.61 768.1
80.99 769.29
81.4 770.47
81.85 771.63
82.34 772.79
82.86 773.92
83.42 775.04
84.02 776.14
84.65 777.22
85.32 778.27
86.01 779.31
86.75 780.32
87.51 781.32
88.3 782.28
89.13 783.22
89.99 784.13
90.87 785.02
91.78 785.87
92.72 786.7
93.69 787.49
94.68 788.25
95.69 788.99
96.73 789.68
97.78 790.35
98.86 790.98
99.96 791.58
101.08 792.14
102.21 792.66
103.37 793.15
104.53 793.6
105.71 794.01
106.9 794.39
108.11 794.72
109.32 795.02
110.55 795.28
111.78 795.5
113.01 795.68
114.26 795.82
115.5 795.92
116.75 795.98
118 796
418 796
419.95 796.03
421.91 796.12
423.86 796.28
425.8 796.5
427.74 796.78
429.66 797.12
431.57 797.53
433.47 797.99
435.36 798.52
437.22 799.11
439.07 799.75
440.89 800.46
442.69 801.22
444.47 802.04
446.22 802.92
447.93 803.85
449.62 804.84
451.28 805.88
452.9 806.97
454.48 808.11
456.03 809.31
457.54 810.55
459.01 811.84
460.44 813.18
461.82 814.56
463.16 815.99
464.45 817.46
465.69 818.97
466.89 820.51
468.03 822.1
469.12 823.72
470.16 825.38
471.15 827.06
472.08 828.78
472.96 830.53
473.78 832.31
474.54 834.11
475.25 835.93
475.89 837.78
476.48 839.64
477.01 841.53
477.47 843.43
477.88 845.34
478.22 847.26
478.5 849.2
478.72 851.14
478.88 853.09
478.97 855.04
479 857
478.97 858.95
478.88 860.91
478.72 862.86
478.5 864.8
478.22 866.74
477.88 868.66
477.47 870.57
477.01 872.47
476.48 874.35
475.89 876.22
475.25 878.07
474.54 879.89
473.78 881.69
472.96 883.47
472.08 885.21
471.15 886.93
470.16 888.62
469.12 890.28
468.03 891.9
466.89 893.48
465.69 895.03
464.45 896.54
463.16 898.01
461.82 899.44
460.44 900.82
459.01 902.16
457.54 903.45
456.03 904.69
454.48 905.89
452.9 907.03
451.28 908.12
449.62 909.16
447.93 910.15
446.22 911.08
444.47 911.96
442.69 912.78
440.89 913.54
439.07 914.25
437.22 914.89
435.36 915.48
433.47 916
431.57 916.47
429.66 916.87
427.74 917.22
425.8 917.5
423.86 917.72
421.91 917.87
419.95 917.97
418 918
118 918
116.75 918.02
115.5 918.08
114.26 918.18
113.01 918.32
111.78 918.5
110.55 918.72
109.32 918.98
108.11 919.28
106.9 919.61
105.71 919.99
104.53 920.4
103.37 920.85
102.21 921.34
101.08 921.86
99.96 922.42
98.86 923.02
97.78 923.65
96.73 924.31
95.69 925.01
94.68 925.74
93.68 926.51
92.72 927.3
91.78 928.13
90.87 928.98
89.99 929.87
89.13 930.78
88.31 931.72
87.51 932.68
86.75 933.67
86.01 934.69
85.32 935.72
84.65 936.78
84.02 937.86
83.42 938.96
82.86 940.08
82.34 941.21
81.85 942.36
81.4 943.53
80.99 944.71
80.61 945.9
80.28 947.11
79.98 948.32
79.72 949.54
79.5 950.78
79.32 952.01
79.18 953.25
79.08 954.5
79.02 955.75
79 957
79.02 958.25
79.08 959.5
79.18 960.74
79.32 961.99
79.5 963.22
79.72 964.45
79.98 965.68
80.28 966.89
80.61 968.1
80.99 969.29
81.4 970.47
81.85 971.63
82.34 972.79
82.86 973.92
83.42 975.04
84.02 976.14
84.65 977.22
85.32 978.28
86.01 979.31
86.75 980.32
87.51 981.31
88.31 982.28
89.13 983.22
89.98 984.13
90.87 985.02
91.78 985.87
92.72 986.7
93.68 987.49
94.67 988.25
95.69 988.99
96.72 989.68
97.78 990.35
98.86 990.98
99.96 991.58
101.08 992.14
102.21 992.66
103.37 993.15
104.53 993.6
105.71 994.01
106.9 994.39
108.11 994.72
109.32 995.02
110.55 995.28
111.78 995.5
113.01 995.68
114.26 995.82
115.5 995.92
116.75 995.98
118 996
418 996
419.95 996.03
421.91 996.12
423.86 996.28
425.8 996.5
427.74 996.78
429.66 997.12
431.57 997.53
433.47 997.99
435.36 998.52
437.22 999.11
439.07 999.75
440.89 1000.46
442.69 1001.22
444.47 1002.04
446.22 1002.92
447.93 1003.85
449.62 1004.83
451.28 1005.88
452.9 1006.97
454.48 1008.11
456.03 1009.31
457.54 1010.55
459.01 1011.84
460.44 1013.18
461.82 1014.56
463.16 1015.99
464.45 1017.46
465.69 1018.97
466.89 1020.51
468.03 1022.1
469.12 1023.72
470.16 1025.38
471.15 1027.07
472.08 1028.78
472.96 1030.53
473.78 1032.31
474.54 1034.11
475.25 1035.93
475.89 1037.78
476.48 1039.64
477.01 1041.53
477.47 1043.43
477.88 1045.34
478.22 1047.26
478.5 1049.2
478.72 1051.14
478.88 1053.09
478.97 1055.04
479 1057
478.97 1058.95
478.88 1060.91
478.72 1062.86
478.5 1064.8
478.22 1066.74
477.88 1068.66
477.47 1070.57
477.01 1072.47
476.48 1074.35
475.89 1076.22
475.25 1078.07
474.54 1079.89
473.78 1081.69
472.96 1083.47
472.08 1085.21
471.15 1086.93
470.16 1088.62
469.12 1090.28
468.03 1091.9
466.89 1093.48
465.69 1095.03
464.45 1096.54
463.16 1098.01
461.82 1099.44
460.44 1100.82
459.01 1102.16
457.54 1103.45
456.03 1104.69
454.48 1105.88
452.9 1107.03
451.28 1108.12
449.62 1109.16
447.93 1110.15
446.22 1111.08
444.47 1111.96
442.69 1112.78
440.89 1113.54
439.07 1114.25
437.22 1114.89
435.36 1115.48
433.47 1116
431.57 1116.47
429.66 1116.87
427.74 1117.22
425.8 1117.5
423.86 1117.72
421.91 1117.87
419.95 1117.97
418 1118
118 1118
116.75 1118.02
115.5 1118.08
114.26 1118.18
113.01 1118.32
111.78 1118.5
110.55 1118.72
109.32 1118.98
108.11 1119.28
106.9 1119.61
105.71 1119.99
104.53 1120.4
103.37 1120.85
102.21 1121.34
101.08 1121.86
99.96 1122.42
98.86 1123.02
97.78 1123.65
96.72 1124.31
95.69 1125.01
94.68 1125.74
93.68 1126.51
92.72 1127.3
91.78 1128.13
90.87 1128.98
89.99 1129.87
89.13 1130.78
88.31 1131.72
87.51 1132.68
86.75 1133.67
86.01 1134.69
85.32 1135.72
84.65 1136.78
84.02 1137.86
83.42 1138.96
82.86 1140.08
82.34 1141.21
81.85 1142.36
81.4 1143.53
80.99 1144.71
80.61 1145.9
80.28 1147.11
79.98 1148.32
79.72 1149.54
79.5 1150.78
79.32 1152.01
79.18 1153.25
79.08 1154.5
79.02 1155.75
79 1157
79.02 1158.25
79.08 1159.5
79.18 1160.74
79.32 1161.99
79.5 1163.22
79.72 1164.45
79.98 1165.68
80.28 1166.89
80.61 1168.1
80.99 1169.29
81.4 1170.47
81.85 1171.63
82.34 1172.79
82.86 1173.92
83.42 1175.04
84.02 1176.14
84.65 1177.22
85.32 1178.28
86.01 1179.31
86.75 1180.32
87.51 1181.32
88.31 1182.28
89.13 1183.22
89.99 1184.13
90.87 1185.01
91.78 1185.87
92.72 1186.69
93.68 1187.49
94.67 1188.25
95.69 1188.99
96.72 1189.68
97.78 1190.35
98.86 1190.98
99.96 1191.58
101.08 1192.14
102.21 1192.66
103.37 1193.15
104.53 1193.6
105.71 1194.01
106.9 1194.39
108.11 1194.72
109.32 1195.02
110.55 1195.28
111.78 1195.5
113.01 1195.68
114.26 1195.82
115.5 1195.92
116.75 1195.98
118 1196
118.98 1196.01
119.96 1196.03
120.93 1196.07
121.91 1196.12
122.88 1196.19
123.86 1196.28
124.83 1196.38
125.8 1196.5
126.77 1196.63
127.74 1196.78
128.7 1196.94
129.66 1197.12
130.62 1197.32
131.58 1197.53
132.53 1197.75
133.47 1197.99
134.42 1198.25
135.36 1198.52
136.29 1198.81
137.22 1199.11
138.15 1199.42
139.07 1199.75
139.98 1200.1
140.89 1200.46
141.8 1200.83
142.69 1201.22
143.58 1201.62
144.47 1202.04
145.35 1202.47
146.22 1202.92
147.08 1203.38
147.93 1203.85
148.78 1204.33
149.62 1204.83
150.45 1205.35
151.28 1205.88
152.09 1206.42
152.9 1206.97
153.7 1207.53
154.49 1208.11
155.26 1208.7
156.03 1209.31
156.79 1209.92
157.54 1210.55
158.28 1211.19
159.01 1211.84
159.73 1212.51
160.44 1213.18
161.14 1213.87
161.82 1214.56
162.49 1215.27
163.16 1215.99
163.81 1216.72
164.45 1217.46
165.08 1218.21
165.69 1218.97
166.3 1219.74
166.89 1220.51
167.47 1221.3
168.03 1222.1
168.58 1222.91
169.12 1223.72
169.65 1224.55
170.16 1225.38
170.67 1226.22
171.15 1227.07
171.62 1227.92
172.08 1228.78
172.53 1229.65
172.96 1230.53
173.38 1231.42
173.78 1232.31
174.17 1233.2
174.54 1234.11
174.9 1235.02
175.25 1235.93
175.58 1236.85
175.89 1237.78
176.19 1238.71
176.48 1239.64
176.75 1240.58
177.01 1241.53
177.25 1242.47
177.47 1243.43
177.68 1244.38
177.88 1245.34
178.06 1246.3
178.22 1247.26
178.37 1248.23
178.5 1249.2
178.62 1250.17
178.72 1251.14
178.81 1252.12
178.88 1253.09
178.93 1254.07
178.97 1255.04
178.99 1256.02
179 1257
179 1261.59
179 1266.18
179 1270.77
179 1272
546 1272
546 657
END
END GEO
OPT
MAX 100
VARS
END
END OPT
VARSWP
END VARSWP
```
